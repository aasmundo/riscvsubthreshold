    U1278 (n1849 n1601 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1044 (n1753 n1159 n1157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U248 (n40 n1760 n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1045 (A\<15\> n1760 n1159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U236 (n253 n252 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U241 (n259 n1753 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U242 (A\<7\> n165 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U249 (n266 n267 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U189 (A\<9\> n164 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U856 (n956 n166 n954 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U857 (n1721 n1757 n956 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U674 (A\<24\> n1757 n763 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U673 (n763 n1753 n761 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U188 (n194 n166 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U863 (n962 n963 n947 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U861 (B\<1\> n1636 n960 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U851 (n949 n950 n948 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U678 (n768 n1581 n764 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U676 (n53 n1866 n765 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U677 (B\<24\> n1599 n766 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U675 (n764 n765 n758 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U323 (n348 n1753 n346 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U324 (A\<4\> n1758 n348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U297 (A\<5\> n1758 n319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1223 (n1565 n165 n1313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U499 (B\<29\> n164 n556 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1123 (n1582 n1728 n1197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U314 (n1725 n1807 n337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U313 (n336 n337 n332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U540 (n600 n601 n585 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U539 (B\<28\> n1664 n599 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U528 (n587 n588 n586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U489 (n545 n546 n544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U311 (n1691 n48 n335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U310 (n334 n335 n333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U495 (n553 n170 n551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U496 (n1623 n1663 n553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U641 (n725 n22 n724 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U192 (n201 n22 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1084 (n1202 n1710 n1200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1085 (A\<14\> n1611 n1202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U356 (A\<3\> n1636 n382 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U355 (n382 n1710 n380 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1091 (n1207 n1208 n1189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1090 (B\<14\> n1664 n1206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1076 (n1192 n1191 n1190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U330 (n354 n355 n339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U274 (B\<6\> n1755 n293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U301 (B\<5\> n1636 n323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U212 (B\<8\> n1611 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U680 (n769 n770 n750 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U663 (n752 n753 n751 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U596 (n671 n672 n670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U613 (n689 n690 n669 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U291 (n312 n313 n311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U303 (n325 n326 n310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U296 (n319 n170 n317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U216 (n231 n170 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U221 (n236 n237 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U209 (n223 n224 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U195 (B\<9\> n1755 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U217 (n141 n1755 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U183 (n188 n1832 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U196 (n206 n207 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U191 (n199 n200 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1831 (n508 n1800 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1787 (n1688 n1754 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1793 (n163 n1760 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1666 (n1759 n1635 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U167 (n642 n166 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1801 (n649 n1769 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1848 (n663 n1817 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1802 (n653 n1770 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1614 (n1759 n1583 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1905 (n1555 n1874 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1903 (n562 n1872 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1898 (B\<25\> n1867 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U37 (n1867 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1896 (A\<22\> n1865 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1636 (n1865 n1605 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1893 (A\<21\> n1862 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U73 (n1862 n72 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1892 (B\<21\> n1861 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U38 (n1861 n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1890 (A\<19\> n1859 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n1859 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1907 (operation\<0\> n1876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1906 (operation\<1\> n1875 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1904 (A\<31\> n1873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1775 (n1873 n1742 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U177 (n1873 n176 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1797 (B\<3\> n1764 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1796 (n1764 n1763 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U120 (n1764 n119 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1902 (B\<31\> n1871 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U181 (n1871 n180 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U179 (n1871 n178 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1901 (n1682 n1870 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U76 (n1870 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1900 (B\<27\> n1869 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1611 (n1869 n1580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (n1869 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1895 (B\<22\> n1864 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1604 (n1864 n1573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (n1864 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1889 (B\<19\> n1858 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1651 (operation\<3\> n1620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1583 (operation\<2\> n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1814 (n1496 n1783 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1810 (n1554 n1779 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1670 (n1132 n1639 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1754 (n1720 n1721 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U170 (n1759 n169 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U168 (n127 n167 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1740 (n1751 n1707 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U85 (n127 n84 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1723 (n127 n1690 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1763 (B\<4\> n1730 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1700 (n1730 n1669 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1699 (n1730 n1668 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n1730 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (A\<0\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1755 (n1720 n1722 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1753 (A\<1\> n1720 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1658 (n1720 n1627 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (n1720 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1874 (A\<2\> n1843 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1739 (n400 n1706 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1659 (n1843 n1628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n1843 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (A\<3\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1777 (n400 n1744 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U128 (n126 n127 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (A\<0\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1660 (n1843 n1629 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U109 (A\<3\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U108 (n108 n107 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U107 (n108 n106 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n108 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1886 (B\<17\> n1855 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1808 (n1100 n1777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1809 (n1104 n1778 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1805 (n892 n1774 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1854 (n1114 n1823 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1697 (n868 n1666 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1752 (n1716 n1719 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U64 (n1716 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1706 (n1672 n1675 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1861 (n1079 n1830 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1722 (n1688 n1689 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1743 (n642 n1710 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1858 (n906 n1827 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1859 (n338 n1828 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1804 (n888 n1773 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1855 (n871 n1824 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1891 (n875 n1860 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1736 (n629 n1703 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1885 (A\<16\> n1854 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1693 (n1854 n1662 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1884 (n2 n1853 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n1853 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1887 (A\<18\> n1856 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U154 (n1856 n153 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n1856 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1692 (A\<17\> n1661 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1620 (n1661 n1589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1883 (A\<14\> n1852 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U70 (n1852 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n1852 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1882 (A\<8\> n1851 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1747 (n1851 n1714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U141 (n1851 n140 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1881 (A\<6\> n1850 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1748 (n1850 n1715 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U159 (n1850 n158 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U158 (n1850 n157 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1880 (n1668 n1849 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1866 (n905 n1835 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1842 (n909 n1811 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1619 (A\<21\> n1588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1856 (n747 n1825 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U155 (n210 n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U156 (n154 n155 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1624 (n1488 n1593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1843 (n817 n1812 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1789 (n163 n1756 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1824 (n233 n1793 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1791 (n163 n1758 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1865 (n799 n1834 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1798 (n1767 n1765 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1799 (n1765 n1766 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1875 (n512 n1844 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1652 (n1620 n1621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1653 (n1620 n1622 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1678 (n454 n1647 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1792 (n195 n1759 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1790 (n1759 n1757 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1774 (A\<31\> n1741 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U178 (n1741 n177 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1721 (n643 n1688 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1631 (n592 n1600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1800 (n1763 n1767 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1627 (n1767 n1596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1795 (B\<2\> n1762 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1794 (n1762 n1761 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1613 (n1762 n1582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U164 (n195 n163 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1788 (n163 n1755 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1773 (n70 n1740 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (A\<30\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n70 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n70 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1772 (n1738 n1739 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1771 (A\<29\> n1738 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1654 (n1738 n1623 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U28 (n1738 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1770 (n1683 n1737 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1769 (n1683 n1736 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1768 (n1683 n1735 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1714 (A\<28\> n1683 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1767 (n1732 n1734 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1765 (A\<4\> n1732 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U102 (n1732 n101 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U101 (n1732 n100 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1766 (n1732 n1733 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1762 (n1563 n1729 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1761 (n1563 n1728 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1594 (B\<1\> n1563 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U74 (n1563 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1759 (B\<0\> n1726 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1738 (n1726 n1705 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1647 (n1726 n1616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1760 (n1726 n1727 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1746 (n1638 n1713 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1669 (A\<9\> n1638 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U89 (n1638 n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n1638 n85 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1625 (n1593 n1594 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1786 (n642 n1753 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U171 (n642 n170 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U180 (n163 n179 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (A\<31\> n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1737 (n1703 n1704 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1864 (n445 n1833 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1726 (n1691 n1693 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1781 (n1653 n1748 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1780 (n1653 n1747 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1778 (n400 n1745 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1782 (n127 n1749 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1871 (n435 n1840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1615 (n730 n1584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1742 (n598 n1709 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1899 (n686 n1868 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U60 (n234 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n59 n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1724 (n443 n1691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1671 (n1840 n1640 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1779 (n1747 n1746 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1764 (n1730 n1731 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1725 (n1691 n1692 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1757 (n1692 n1724 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1756 (n1692 n1723 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1718 (n1747 n1685 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1713 (n175 n1682 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U176 (A\<27\> n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U77 (n175 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1712 (n1569 n1681 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1711 (n1569 n1680 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1638 (n1569 n1607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1600 (A\<26\> n1569 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1705 (n1672 n1674 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1704 (n1672 n1673 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1812 (n930 n1781 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n1822 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1894 (n836 n1863 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1888 (n1003 n1857 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1836 (n999 n1805 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1813 (n1019 n1782 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1640 (n767 n1609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1612 (n1609 n1581 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1691 (A\<17\> n1660 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U45 (n1660 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1618 (n90 n1587 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U91 (A\<15\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1610 (n1578 n1579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1609 (B\<29\> n1578 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1608 (n1576 n1577 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1607 (B\<13\> n1576 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1710 (A\<26\> n1679 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1709 (A\<13\> n1678 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1702 (n1670 n1671 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1701 (A\<20\> n1670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1593 (n1670 n1562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1689 (n56 n1658 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1622 (n56 n1591 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (A\<23\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1688 (n1656 n1657 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1687 (A\<11\> n1656 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n1656 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1686 (n1654 n1655 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1685 (A\<12\> n1654 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U16 (n1654 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1677 (A\<25\> n1646 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1668 (n1646 n1637 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U75 (n1646 n74 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1673 (n1671 n1642 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1672 (n1582 n1641 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U39 (n1641 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1741 (n1641 n1708 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1657 (n1625 n1626 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1656 (B\<6\> n1625 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n1625 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1646 (n1613 n1615 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1645 (n1613 n1614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1644 (B\<8\> n1613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1606 (n1574 n1575 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1605 (B\<20\> n1574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1584 (n1574 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1720 (n1686 n1687 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1719 (n718 n1686 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n1858 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U97 (n95 n96 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U96 (A\<19\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1849 (n785 n1818 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1830 (n1342 n1799 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1730 (n441 n1697 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1675 (n1643 n1644 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U136 (n1752 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U140 (n1752 n139 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1758 (n1699 n1725 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1827 (n1461 n1796 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1596 (n1564 n1565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1595 (B\<12\> n1564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1589 (n1557 n1558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1588 (B\<26\> n1557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1683 (n400 n1652 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1603 (n1570 n1572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1602 (n1570 n1571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1601 (B\<9\> n1570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1599 (n1566 n1568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1598 (n1566 n1567 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1597 (B\<28\> n1566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1592 (n1559 n1561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1591 (n1559 n1560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1590 (B\<18\> n1559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1587 (n183 n185 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1586 (n183 n184 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1585 (B\<24\> n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U175 (n173 n174 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U174 (A\<5\> n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U95 (n173 n94 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1661 (n1818 n1630 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1732 (n1698 n1699 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1731 (n615 n1698 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1641 (n1698 n1610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U173 (A\<24\> n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U169 (n1662 n168 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U157 (n81 n156 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U84 (n81 n83 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U83 (n81 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (A\<7\> n81 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U151 (n1699 n150 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U138 (n1752 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U113 (n1699 n112 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (A\<23\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U150 (n1747 n149 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n1747 n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1844 (n736 n1813 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U88 (n598 n87 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1852 (n1125 n1821 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1853 (n352 n1822 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U144 (n1666 n143 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U142 (n1851 n141 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U87 (A\<9\> n86 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U81 (A\<10\> n80 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U80 (n80 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U123 (n120 n122 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U122 (n120 n121 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U121 (B\<10\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U119 (n1637 n118 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U106 (n104 n105 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U105 (B\<14\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n104 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U104 (n102 n103 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U103 (B\<11\> n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n102 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U100 (n97 n99 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U99 (n97 n98 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U98 (B\<15\> n97 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U94 (n91 n93 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U93 (n91 n92 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U92 (B\<5\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U79 (n77 n78 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (A\<10\> n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n77 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (A\<26\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (A\<16\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n49 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1784 (n1676 n1751 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1835 (n389 n1804 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1734 (n828 n1701 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U145 (n1183 n144 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1707 (n401 n1676 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1815 (n1548 n1784 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1838 (n982 n1807 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1851 (n536 n1820 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1820 (n1545 n1789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1857 (n408 n1826 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U160 (n898 n159 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U161 (n159 n160 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U147 (n1229 n146 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1829 (n1457 n1798 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1839 (n989 n1808 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U48 (n1534 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1841 (n1392 n1810 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U143 (n1733 n142 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U125 (n400 n124 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U124 (n400 n123 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (A\<5\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U53 (n1747 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (A\<13\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n41 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1628 (n1461 n1597 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U111 (n1595 n110 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (n1747 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U148 (n1747 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1828 (n627 n1797 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U163 (n161 n162 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U162 (n1110 n161 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1783 (n1595 n1750 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U149 (n1747 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1684 (n404 n1653 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1626 (n1676 n1595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1649 (n1747 n1618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (A\<14\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U126 (n127 n125 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (n442 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n57 n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U110 (n1595 n109 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n591 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (n61 n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1681 (n1649 n1650 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1825 (n697 n1794 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1634 (n740 n1603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1635 (n1603 n1604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1867 (n1266 n1836 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U112 (n1595 n111 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1832 (n776 n1801 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U130 (n127 n129 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U129 (n127 n128 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1621 (n1521 n1590 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U127 (n405 n126 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n39 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (B\<7\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (B\<16\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U116 (n1595 n115 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (A\<24\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (n53 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U172 (n1595 n171 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U137 (n1752 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1840 (n1396 n1809 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1629 (n1396 n1598 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1845 (n1176 n1814 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1877 (n1251 n1846 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U134 (n1752 n133 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1682 (n1649 n1651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1803 (n727 n1771 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1616 (n1584 n1585 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U72 (n1730 n71 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1674 (n429 n1643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1676 (n1643 n1645 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1633 (n1600 n1602 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1632 (n1600 n1601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1664 (n721 n1633 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1785 (n1633 n1752 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1665 (n1633 n1634 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U139 (n1752 n138 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1617 (n163 n1586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1717 (n1743 n1684 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1703 (n677 n1672 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1822 (n1326 n1791 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1846 (n1034 n1815 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n1766 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U135 (n1752 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1821 (n865 n1790 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1663 (n1631 n1632 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1817 (n832 n1786 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1811 (n852 n1780 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1643 (n642 n1612 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1696 (n1697 n1665 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1749 (n637 n1716 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1750 (n1716 n1717 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1751 (n1716 n1718 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1648 (n1743 n1617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U68 (n66 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n687 n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1834 (n1422 n1803 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1869 (n1088 n1838 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1833 (n1222 n1802 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1847 (n648 n1816 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1862 (n202 n1831 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U90 (n598 n89 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1776 (n219 n1743 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1662 (n668 n1631 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1860 (n1092 n1829 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1639 (n722 n1608 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1637 (n1743 n1606 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U23 (n1831 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1680 (n696 n1649 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1837 (n798 n1806 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1698 (n1666 n1667 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1816 (n1068 n1785 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1806 (n1054 n1775 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1818 (n1236 n1787 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1873 (n1314 n1842 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1819 (n704 n1788 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1650 (n521 n1619 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U153 (n1692 n152 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U152 (n1692 n151 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1807 (n1058 n1776 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1735 (n496 n1702 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1826 (n1045 n1795 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U114 (n1699 n113 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U146 (n1275 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (n1275 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1708 (n116 n1677 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U117 (n1595 n116 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1850 (n249 n1819 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1727 (n294 n1694 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1679 (n1647 n1648 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n1647 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1744 (n606 n1711 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U131 (n196 n130 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U133 (n130 n132 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1879 (n263 n1848 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1897 (n766 n1866 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1630 (n163 n1599 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1868 (n1426 n1837 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1870 (n557 n1839 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1655 (n1839 n1624 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1872 (n1197 n1841 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U132 (n130 n131 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U166 (n163 n165 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U165 (n163 n164 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1623 (n1841 n1592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1733 (n114 n1700 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U115 (n1699 n114 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n1691 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1694 (n163 n1663 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1642 (n163 n1611 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1690 (n725 n1659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1876 (n201 n1845 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U118 (n1765 n117 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1878 (n1204 n1847 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1823 (n349 n1792 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U56 (n1711 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1745 (n1711 n1712 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1729 (n1694 n1696 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1728 (n1694 n1695 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1695 (n1759 n1664 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1667 (n1759 n1636 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1863 (n198 n1832 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U1716 (n788 result\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx1_PB4_AFBB
    U1715 (n415 result\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx1_PB4_AFBB
    lt_29 (n1742 A\<30\> n1739 n1735 n1682 A\<26\> n1637 A\<24\> A\<23\> \
        A\<22\> A\<21\> n1671 A\<19\> A\<18\> n1589 A\<16\> A\<15\> \
        A\<14\> A\<13\> n1655 A\<11\> A\<10\> n1713 A\<8\> n156 A\<6\> \
        A\<5\> A\<4\> A\<3\> A\<2\> A\<1\> A\<0\> n180 B\<30\> B\<29\> \
        n1568 n1580 n1558 n36 n185 B\<23\> n1573 B\<21\> n1575 B\<19\> \
        n1560 B\<17\> n2 n98 n105 B\<13\> n1565 n103 n122 n1571 n1615 n40 \
        n1626 n92 n1669 n1596 n38 B\<1\> n1705 GND! VDD! N18 NeTt_5477 \
        inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_alu_DW01_cmp2_1_schematic
    lt_32 (A\<31\> A\<30\> A\<29\> A\<28\> n1682 n1680 A\<25\> A\<24\> \
        A\<23\> A\<22\> A\<21\> n1671 A\<19\> A\<18\> n1589 n1662 A\<15\> \
        A\<14\> A\<13\> A\<12\> A\<11\> n78 n1713 A\<8\> n156 n1715 A\<5\> \
        n1734 A\<3\> A\<2\> n8 A\<0\> B\<31\> B\<30\> B\<29\> n1568 n1580 \
        n1558 n36 n185 B\<23\> n1573 B\<21\> n1575 B\<19\> n1561 B\<17\> \
        n2 n98 n105 B\<13\> n1565 B\<11\> B\<10\> n1571 n1615 n40 B\<6\> \
        B\<5\> n1668 n1596 n1582 n1728 n1616 GND! GND! N19 NeTt_5478 \
        inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_alu_DW01_cmp2_0_schematic
    sub_28 (n177 n1740 n1623 n1737 n76 n1607 n74 A\<24\> n1591 A\<22\> n72 \
        n1562 n96 n68 n44 n1662 A\<15\> n69 n17 A\<12\> n19 n9 n85 n1714 \
        n82 n157 n94 n100 n106 n24 n1627 A\<0\> n180 B\<30\> B\<29\> n1568 \
        n1580 n1558 B\<25\> n185 B\<23\> B\<22\> B\<21\> n1575 B\<19\> \
        n1561 B\<17\> n2 B\<15\> B\<14\> B\<13\> n1565 n103 B\<10\> n1571 \
        n1615 n40 n1626 n92 B\<4\> n1763 n1582 n1729 n1705 GND! \
        sub_res\<31\> sub_res\<30\> sub_res\<29\> sub_res\<28\> \
        sub_res\<27\> sub_res\<26\> sub_res\<25\> sub_res\<24\> \
        sub_res\<23\> sub_res\<22\> sub_res\<21\> sub_res\<20\> \
        sub_res\<19\> sub_res\<18\> sub_res\<17\> sub_res\<16\> \
        sub_res\<15\> sub_res\<14\> sub_res\<13\> sub_res\<12\> \
        sub_res\<11\> sub_res\<10\> sub_res\<9\> sub_res\<8\> sub_res\<7\> \
        sub_res\<6\> sub_res\<5\> sub_res\<4\> sub_res\<3\> sub_res\<2\> \
        sub_res\<1\> sub_res\<0\> NeTt_5479 inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_alu_DW01_sub_0_schematic
    add_27 (n176 n45 n27 n1736 n75 n1681 n1637 n42 n1658 n1605 A\<21\> \
        A\<20\> n34 n153 n1589 n31 n1587 n43 A\<13\> n10 n1657 n79 n88 \
        n140 n83 n158 n174 n101 n33 n1628 n1722 A\<0\> n178 B\<30\> n1579 \
        n1567 n18 n1558 B\<25\> n184 B\<23\> n20 n37 n182 n3 B\<18\> \
        B\<17\> n32 n99 n28 n1577 n1565 n26 n121 n1572 n1614 n40 n6 n93 \
        n16 n119 n1761 n73 n1616 GND! add_res\<31\> add_res\<30\> \
        add_res\<29\> add_res\<28\> add_res\<27\> add_res\<26\> \
        add_res\<25\> add_res\<24\> add_res\<23\> add_res\<22\> \
        add_res\<21\> add_res\<20\> add_res\<19\> add_res\<18\> \
        add_res\<17\> add_res\<16\> add_res\<15\> add_res\<14\> \
        add_res\<13\> add_res\<12\> add_res\<11\> add_res\<10\> \
        add_res\<9\> add_res\<8\> add_res\<7\> add_res\<6\> add_res\<5\> \
        add_res\<4\> add_res\<3\> add_res\<2\> add_res\<1\> add_res\<0\> \
        NeTt_5480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_alu_DW01_add_0_schematic
ends soc_no_opt_16may_alu_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: execute
// View name: schematic
subckt soc_no_opt_16may_execute_schematic ALU_operation\<3\> \
        ALU_operation\<2\> ALU_operation\<1\> ALU_operation\<0\> \
        reg1\<31\> reg1\<30\> reg1\<29\> reg1\<28\> reg1\<27\> reg1\<26\> \
        reg1\<25\> reg1\<24\> reg1\<23\> reg1\<22\> reg1\<21\> reg1\<20\> \
        reg1\<19\> reg1\<18\> reg1\<17\> reg1\<16\> reg1\<15\> reg1\<14\> \
        reg1\<13\> reg1\<12\> reg1\<11\> reg1\<10\> reg1\<9\> reg1\<8\> \
        reg1\<7\> reg1\<6\> reg1\<5\> reg1\<4\> reg1\<3\> reg1\<2\> \
        reg1\<1\> reg1\<0\> reg2\<31\> reg2\<30\> reg2\<29\> reg2\<28\> \
        reg2\<27\> reg2\<26\> reg2\<25\> reg2\<24\> reg2\<23\> reg2\<22\> \
        reg2\<21\> reg2\<20\> reg2\<19\> reg2\<18\> reg2\<17\> reg2\<16\> \
        reg2\<15\> reg2\<14\> reg2\<13\> reg2\<12\> reg2\<11\> reg2\<10\> \
        reg2\<9\> reg2\<8\> reg2\<7\> reg2\<6\> reg2\<5\> reg2\<4\> \
        reg2\<3\> reg2\<2\> reg2\<1\> reg2\<0\> imm\<31\> imm\<30\> \
        imm\<29\> imm\<28\> imm\<27\> imm\<26\> imm\<25\> imm\<24\> \
        imm\<23\> imm\<22\> imm\<21\> imm\<20\> imm\<19\> imm\<18\> \
        imm\<17\> imm\<16\> imm\<15\> imm\<14\> imm\<13\> imm\<12\> \
        imm\<11\> imm\<10\> imm\<9\> imm\<8\> imm\<7\> imm\<6\> imm\<5\> \
        imm\<4\> imm\<3\> imm\<2\> imm\<1\> imm\<0\> is_imm rs1\<4\> \
        rs1\<3\> rs1\<2\> rs1\<1\> rs1\<0\> rs2\<4\> rs2\<3\> rs2\<2\> \
        rs2\<1\> rs2\<0\> rs2_out\<31\> rs2_out\<30\> rs2_out\<29\> \
        rs2_out\<28\> rs2_out\<27\> rs2_out\<26\> rs2_out\<25\> \
        rs2_out\<24\> rs2_out\<23\> rs2_out\<22\> rs2_out\<21\> \
        rs2_out\<20\> rs2_out\<19\> rs2_out\<18\> rs2_out\<17\> \
        rs2_out\<16\> rs2_out\<15\> rs2_out\<14\> rs2_out\<13\> \
        rs2_out\<12\> rs2_out\<11\> rs2_out\<10\> rs2_out\<9\> \
        rs2_out\<8\> rs2_out\<7\> rs2_out\<6\> rs2_out\<5\> rs2_out\<4\> \
        rs2_out\<3\> rs2_out\<2\> rs2_out\<1\> rs2_out\<0\> rd\<4\> \
        rd\<3\> rd\<2\> rd\<1\> rd\<0\> current_PC\<10\> current_PC\<9\> \
        current_PC\<8\> current_PC\<7\> current_PC\<6\> current_PC\<5\> \
        current_PC\<4\> current_PC\<3\> current_PC\<2\> current_PC\<1\> \
        current_PC\<0\> reg_or_PC rd_dest_mem\<4\> rd_dest_mem\<3\> \
        rd_dest_mem\<2\> rd_dest_mem\<1\> rd_dest_mem\<0\> \
        rs2_adr_mem\<4\> rs2_adr_mem\<3\> rs2_adr_mem\<2\> \
        rs2_adr_mem\<1\> rs2_adr_mem\<0\> rd_data_mem\<31\> \
        rd_data_mem\<30\> rd_data_mem\<29\> rd_data_mem\<28\> \
        rd_data_mem\<27\> rd_data_mem\<26\> rd_data_mem\<25\> \
        rd_data_mem\<24\> rd_data_mem\<23\> rd_data_mem\<22\> \
        rd_data_mem\<21\> rd_data_mem\<20\> rd_data_mem\<19\> \
        rd_data_mem\<18\> rd_data_mem\<17\> rd_data_mem\<16\> \
        rd_data_mem\<15\> rd_data_mem\<14\> rd_data_mem\<13\> \
        rd_data_mem\<12\> rd_data_mem\<11\> rd_data_mem\<10\> \
        rd_data_mem\<9\> rd_data_mem\<8\> rd_data_mem\<7\> \
        rd_data_mem\<6\> rd_data_mem\<5\> rd_data_mem\<4\> \
        rd_data_mem\<3\> rd_data_mem\<2\> rd_data_mem\<1\> \
        rd_data_mem\<0\> rd_we_mem rd_dest_wb\<4\> rd_dest_wb\<3\> \
        rd_dest_wb\<2\> rd_dest_wb\<1\> rd_dest_wb\<0\> rd_data_wb\<31\> \
        rd_data_wb\<30\> rd_data_wb\<29\> rd_data_wb\<28\> \
        rd_data_wb\<27\> rd_data_wb\<26\> rd_data_wb\<25\> \
        rd_data_wb\<24\> rd_data_wb\<23\> rd_data_wb\<22\> \
        rd_data_wb\<21\> rd_data_wb\<20\> rd_data_wb\<19\> \
        rd_data_wb\<18\> rd_data_wb\<17\> rd_data_wb\<16\> \
        rd_data_wb\<15\> rd_data_wb\<14\> rd_data_wb\<13\> \
        rd_data_wb\<12\> rd_data_wb\<11\> rd_data_wb\<10\> rd_data_wb\<9\> \
        rd_data_wb\<8\> rd_data_wb\<7\> rd_data_wb\<6\> rd_data_wb\<5\> \
        rd_data_wb\<4\> rd_data_wb\<3\> rd_data_wb\<2\> rd_data_wb\<1\> \
        rd_data_wb\<0\> rd_we_wb ALU_result\<31\> ALU_result\<30\> \
        ALU_result\<29\> ALU_result\<28\> ALU_result\<27\> \
        ALU_result\<26\> ALU_result\<25\> ALU_result\<24\> \
        ALU_result\<23\> ALU_result\<22\> ALU_result\<21\> \
        ALU_result\<20\> ALU_result\<19\> ALU_result\<18\> \
        ALU_result\<17\> ALU_result\<16\> ALU_result\<15\> \
        ALU_result\<14\> ALU_result\<13\> ALU_result\<12\> \
        ALU_result\<11\> ALU_result\<10\> ALU_result\<9\> ALU_result\<8\> \
        ALU_result\<7\> ALU_result\<6\> ALU_result\<5\> ALU_result\<4\> \
        ALU_result\<3\> ALU_result\<2\> ALU_result\<1\> ALU_result\<0\> \
        mem_rs2_src inh_gnd inh_gnds inh_vdd_rename inh_vdds
    Vexecute (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    U403 (n67 rd_data_wb\<31\> n358 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U408 (n67 rd_data_wb\<30\> n363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U402 (n68 reg1\<31\> n359 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U424 (n68 reg1\<28\> n381 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U401 (n358 n359 n356 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (reg2\<31\> n10 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n79 rd_data_wb\<31\> n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n140 n141 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U407 (n76 reg1\<30\> n364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U406 (n363 n364 n361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (reg2\<30\> n10 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n80 rd_data_wb\<30\> n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n147 n148 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U420 (n50 rd_data_wb\<29\> n375 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U440 (n50 rd_data_wb\<25\> n395 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U419 (n59 reg1\<29\> n376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U434 (n59 reg1\<26\> n391 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U418 (n375 n376 n373 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (reg2\<29\> n10 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n79 rd_data_wb\<29\> n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n160 n161 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U425 (n73 rd_data_wb\<28\> n380 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U423 (n380 n381 n378 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (reg2\<28\> n10 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n79 rd_data_wb\<28\> n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (n167 n168 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U429 (n312 reg1\<27\> n386 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U430 (n58 rd_data_wb\<27\> n385 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U428 (n385 n386 n383 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (reg2\<27\> n10 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n36 rd_data_wb\<27\> n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (n36 rd_data_wb\<25\> n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n174 n175 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U435 (rd_data_wb\<26\> n43 n390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U433 (n390 n391 n388 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (reg2\<26\> n10 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n51 rd_data_wb\<26\> n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (n181 n182 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U439 (n312 reg1\<25\> n396 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U438 (n395 n396 n393 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (reg2\<25\> n10 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n188 n189 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U536 (n545 n71 n488 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n542 n81 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n135 n136 ALU_b_in\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (imm\<31\> is_imm n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n540 n81 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n142 n143 ALU_b_in\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (imm\<30\> is_imm n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n538 n81 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n155 n156 ALU_b_in\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (imm\<29\> is_imm n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n532 n81 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n176 n177 ALU_b_in\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (imm\<26\> is_imm n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U205 (n530 n81 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (n183 n184 ALU_b_in\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (imm\<25\> is_imm n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U534 (reg1\<0\> n69 n484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U531 (rd_data_wb\<0\> n73 n485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U465 (n73 rd_data_wb\<20\> n420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U530 (n484 n485 n480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U527 (n64 rd_data_mem\<0\> n483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U529 (current_PC\<0\> n45 n482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U526 (n482 n483 n481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U444 (n69 reg1\<24\> n401 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U445 (n43 rd_data_wb\<24\> n400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U455 (n43 rd_data_wb\<22\> n410 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U443 (n400 n401 n398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (reg2\<24\> n10 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n97 rd_data_wb\<24\> n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n195 n196 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U450 (n50 rd_data_wb\<23\> n405 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U449 (n59 reg1\<23\> n406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U448 (n405 n406 n403 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (reg2\<23\> n10 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (n51 rd_data_wb\<23\> n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (n202 n203 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U454 (n59 reg1\<22\> n411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U453 (n410 n411 n408 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (reg2\<22\> n10 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U232 (n51 rd_data_wb\<22\> n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n209 n210 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U460 (n67 rd_data_wb\<21\> n415 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U459 (n75 reg1\<21\> n416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U458 (n415 n416 n413 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U241 (reg2\<21\> n10 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n35 rd_data_wb\<21\> n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n216 n217 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U464 (n77 reg1\<20\> n421 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U463 (n420 n421 n418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (reg2\<20\> n10 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U248 (n51 rd_data_wb\<20\> n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U247 (n223 n224 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U477 (n67 rd_data_wb\<19\> n432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U476 (n76 reg1\<19\> n433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U475 (n432 n433 n430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U265 (reg2\<19\> n10 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n51 rd_data_wb\<19\> n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U263 (n236 n237 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U481 (n77 reg1\<18\> n438 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U482 (rd_data_wb\<18\> n58 n437 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U480 (n437 n438 n435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (reg2\<18\> n10 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n35 rd_data_wb\<18\> n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U271 (n243 n244 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U487 (n67 rd_data_wb\<17\> n442 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U486 (n69 reg1\<17\> n443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U485 (n442 n443 n440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (n526 n81 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (n197 n198 ALU_b_in\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (imm\<23\> is_imm n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n522 n81 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n211 n212 ALU_b_in\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (imm\<21\> is_imm n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n520 n81 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (n218 n219 ALU_b_in\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (imm\<20\> is_imm n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (n518 n81 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n231 n232 ALU_b_in\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (imm\<19\> is_imm n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n516 n81 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n238 n239 ALU_b_in\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (imm\<18\> is_imm n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n97 rd_data_wb\<7\> n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (reg2\<7\> n10 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n494 n107 n570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n44 rd_data_mem\<7\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n109 n110 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U492 (rd_data_wb\<16\> n50 n447 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U491 (n69 reg1\<16\> n448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U377 (reg1\<6\> n69 n332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U490 (n447 n448 n445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U376 (n50 rd_data_wb\<6\> n333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U375 (n332 n333 n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U373 (n64 rd_data_mem\<6\> n331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U374 (current_PC\<6\> n45 n330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U521 (current_PC\<10\> n45 n475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U372 (n330 n331 n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U289 (reg2\<16\> n10 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U288 (n80 rd_data_wb\<16\> n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U296 (n80 rd_data_wb\<15\> n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U287 (n257 n258 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U497 (n67 rd_data_wb\<15\> n452 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U496 (n76 reg1\<15\> n453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U495 (n452 n453 n450 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U297 (reg2\<15\> n10 n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U295 (n264 n265 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U502 (n73 rd_data_wb\<14\> n457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U501 (n68 reg1\<14\> n458 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U524 (reg1\<10\> n68 n477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U500 (n457 n458 n455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U305 (reg2\<14\> n10 n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U304 (n35 rd_data_wb\<14\> n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U303 (n271 n272 n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U507 (n50 rd_data_wb\<13\> n462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U506 (n75 reg1\<13\> n463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U511 (n75 reg1\<12\> n467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U505 (n462 n463 n460 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U313 (reg2\<13\> n10 n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U312 (n66 rd_data_wb\<13\> n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U311 (n278 n279 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U523 (rd_data_wb\<10\> n43 n478 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U522 (n477 n478 n473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U520 (n309 rd_data_mem\<10\> n476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U519 (n475 n476 n474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U355 (rd_data_wb\<9\> n67 n311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U356 (reg1\<9\> n77 n310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U354 (n310 n311 n305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U509 (n65 rd_data_mem\<12\> n464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U508 (n505 n464 ALU_a_in\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U510 (n466 n467 n465 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U512 (n73 rd_data_wb\<12\> n466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U532 (reg_a_src\<0\> n487 n486 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n570 n81 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n105 n106 ALU_b_in\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (imm\<7\> is_imm n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U285 (n512 n81 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U284 (n252 n253 ALU_b_in\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U291 (imm\<16\> is_imm n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U301 (n508 n81 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U300 (n266 n267 ALU_b_in\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U307 (imm\<14\> is_imm n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U309 (n506 n81 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U308 (n273 n274 ALU_b_in\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U315 (imm\<13\> is_imm n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U414 (n50 rd_data_wb\<2\> n371 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U413 (n370 n371 n366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U415 (reg1\<2\> n76 n370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U384 (reg1\<5\> n76 n339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U517 (n58 rd_data_wb\<11\> n470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U513 (n503 n468 ALU_a_in\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U514 (rd_data_mem\<11\> n64 n468 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U516 (n77 reg1\<11\> n471 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U391 (reg1\<4\> n77 n346 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U515 (n470 n471 n469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U390 (n58 rd_data_wb\<4\> n347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U389 (n346 n347 n342 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U387 (n65 rd_data_mem\<4\> n345 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U388 (current_PC\<4\> n72 n344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U412 (current_PC\<2\> n72 n368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U386 (n344 n345 n343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U411 (n64 rd_data_mem\<2\> n369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U410 (n368 n369 n367 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U362 (rd_data_wb\<8\> n58 n319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U363 (reg1\<8\> n68 n318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U398 (reg1\<3\> n312 n353 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U361 (n318 n319 n314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U471 (rd_data_wb\<1\> n58 n428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U472 (reg1\<1\> n75 n427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U370 (reg1\<7\> n75 n325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U368 (n325 n326 n321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U369 (n43 rd_data_wb\<7\> n326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U470 (n427 n428 n423 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U468 (n65 rd_data_mem\<1\> n426 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U469 (current_PC\<1\> n53 n425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U467 (n425 n426 n424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U397 (rd_data_wb\<3\> n43 n354 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U396 (n353 n354 n349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U395 (current_PC\<3\> n52 n351 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U394 (n65 rd_data_mem\<3\> n352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U393 (n351 n352 n350 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U360 (current_PC\<8\> n52 n316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U359 (n65 rd_data_mem\<8\> n317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U358 (n316 n317 n315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U383 (rd_data_wb\<5\> n43 n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U382 (n339 n340 n335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U381 (current_PC\<5\> n53 n337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U367 (current_PC\<7\> n53 n323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U365 (n323 n324 n322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U366 (n309 rd_data_mem\<7\> n324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U380 (n309 rd_data_mem\<5\> n338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U379 (n337 n338 n336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U342 (n300 n82 n574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U348 (n21 rd_data_mem\<0\> n300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U344 (n66 rd_data_wb\<0\> n303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U346 (reg2\<0\> n10 n302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U343 (n302 n303 n301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n80 rd_data_wb\<6\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (reg2\<6\> n10 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n492 n113 n571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n1 rd_data_mem\<6\> n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n115 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U258 (reg_b_src\<1\> rd_data_mem\<1\> n227 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U254 (n84 n227 rs2_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U257 (reg2\<1\> n10 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U256 (n79 rd_data_wb\<1\> n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U255 (n229 n230 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (rd_data_wb\<3\> n79 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (reg2\<3\> n10 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n88 n131 n573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n44 rd_data_mem\<3\> n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n133 n134 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U352 (n64 rd_data_mem\<9\> n308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U351 (n307 n308 n306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U353 (n52 current_PC\<9\> n307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (n514 n81 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n245 n246 ALU_b_in\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U283 (imm\<17\> is_imm n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U349 (imm\<0\> is_imm n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U340 (n298 n299 ALU_b_in\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U341 (n574 n81 n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n571 n81 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n111 n112 ALU_b_in\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (imm\<6\> is_imm n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n573 n81 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n129 n130 ALU_b_in\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (imm\<3\> is_imm n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U339 (imm\<10\> is_imm n292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U332 (n292 n293 ALU_b_in\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (n567 n81 n293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U338 (n1 rd_data_mem\<10\> n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U334 (n500 n294 n567 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (reg2\<10\> n10 n296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U336 (n66 rd_data_wb\<10\> n297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U335 (n296 n297 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U331 (imm\<11\> is_imm n286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U324 (n286 n287 ALU_b_in\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (n566 n81 n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U330 (rd_data_mem\<11\> n1 n288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U326 (n288 n502 n566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U329 (reg2\<11\> n10 n290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U328 (n66 rd_data_wb\<11\> n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (n290 n291 n289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U322 (n1 rd_data_mem\<12\> n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U317 (n565 n81 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U316 (n280 n281 ALU_b_in\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U323 (imm\<12\> is_imm n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U318 (n282 n504 n565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U321 (reg2\<12\> n10 n284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U320 (n36 rd_data_wb\<12\> n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U319 (n284 n285 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (rd_data_wb\<2\> n36 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n153 n154 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (reg2\<2\> n10 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n151 n86 rs2_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n44 rd_data_mem\<2\> n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n44 rd_data_mem\<4\> n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n90 n125 rs2_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (reg2\<4\> n10 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (rd_data_wb\<4\> n66 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n127 n128 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (rd_data_wb\<9\> n66 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (reg2\<9\> n10 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n95 n96 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (rd_data_mem\<9\> n21 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n568 n81 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n91 n92 ALU_b_in\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (imm\<9\> is_imm n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n498 n93 n568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (imm\<5\> is_imm n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n117 n118 ALU_b_in\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n572 n81 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n21 rd_data_mem\<5\> n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n121 n122 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (reg2\<5\> n10 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n490 n119 n572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (imm\<8\> is_imm n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n99 n100 ALU_b_in\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n569 n81 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n21 rd_data_mem\<8\> n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n496 n101 n569 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (reg2\<8\> n10 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n35 rd_data_wb\<8\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n103 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n35 rd_data_wb\<5\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U299 (imm\<15\> is_imm n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U292 (n259 n260 ALU_b_in\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (rs2_out\<15\> n81 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (reg2\<17\> n10 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (n250 n251 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U280 (n36 rd_data_wb\<17\> n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (imm\<1\> is_imm n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (n225 n226 ALU_b_in\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U253 (rs2_out\<1\> n81 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U235 (imm\<22\> is_imm n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n204 n205 ALU_b_in\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (rs2_out\<22\> n81 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (imm\<24\> is_imm n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (n190 n191 ALU_b_in\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (rs2_out\<24\> n81 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (imm\<27\> is_imm n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n169 n170 ALU_b_in\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (rs2_out\<27\> n81 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (imm\<28\> is_imm n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n162 n163 ALU_b_in\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (rs2_out\<28\> n81 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (imm\<2\> is_imm n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n149 n150 ALU_b_in\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (rs2_out\<2\> n81 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (rs2_out\<4\> n81 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n123 n124 ALU_b_in\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (imm\<4\> is_imm n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U591 (n355 n543 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U590 (n137 n542 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U589 (n360 n541 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U588 (n144 n540 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U587 (n372 n539 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U586 (n157 n538 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U585 (n377 n537 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U584 (n164 rs2_out\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U583 (n382 n535 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U582 (n171 rs2_out\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U581 (n387 n533 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U580 (n178 n532 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U579 (n392 n531 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U578 (n185 n530 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U593 (reg_a_src\<1\> n545 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n309 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U53 (n71 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (is_imm n81 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U72 (reg_or_PC n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U612 (rd_data_mem\<13\> n564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U611 (rd_data_mem\<14\> n563 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U610 (rd_data_mem\<15\> n562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U609 (rd_data_mem\<16\> n561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U608 (rd_data_mem\<17\> n560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U607 (rd_data_mem\<18\> n559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U606 (rd_data_mem\<19\> n558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U605 (rd_data_mem\<20\> n557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U604 (rd_data_mem\<21\> n556 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U603 (rd_data_mem\<22\> n555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U602 (rd_data_mem\<23\> n554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U601 (rd_data_mem\<24\> n553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U600 (rd_data_mem\<25\> n552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U599 (rd_data_mem\<26\> n551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U598 (rd_data_mem\<27\> n550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U597 (rd_data_mem\<28\> n549 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U596 (rd_data_mem\<29\> n548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U595 (rd_data_mem\<30\> n547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U594 (rd_data_mem\<31\> n546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U84 (n479 n83 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n28 n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U577 (n397 n529 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U576 (n192 rs2_out\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n97 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U575 (n402 n527 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U574 (n199 n526 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U573 (n407 n525 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U572 (n206 rs2_out\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U571 (n412 n523 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U570 (n213 n522 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (n78 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U569 (n417 n521 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U568 (n220 n520 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U567 (n429 n519 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U566 (n233 n518 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n78 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U565 (n434 n517 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U564 (n240 n516 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U563 (n439 n515 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U562 (n247 n514 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (n78 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (n78 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n78 n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (n34 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n34 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U592 (reg_b_src\<0\> n544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n70 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U542 (n108 n494 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n70 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U561 (n444 n513 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U560 (n254 n512 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U541 (n327 n493 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U559 (n449 n511 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U558 (n261 rs2_out\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U557 (n454 n509 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U556 (n268 n508 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U555 (n459 n507 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U554 (n275 n506 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U549 (n472 n501 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n74 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U547 (n304 n499 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n28 n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U553 (n465 n505 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n71 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U74 (n486 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (reg_b_src\<1\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U2 (n70 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n71 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U73 (n71 n72 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U68 (n74 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (n73 n74 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (n74 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n74 n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U551 (n469 n503 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U537 (n341 n489 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U88 (n365 n87 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U545 (n313 n497 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n78 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U79 (n312 n78 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n422 n85 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U90 (n348 n89 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U539 (n334 n491 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U543 (n320 n495 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U83 (n301 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n34 n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U81 (n34 n80 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U540 (n114 n492 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n9 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n98 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U85 (n228 n84 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U89 (n132 n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n62 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (ALU_b_in\<17\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U62 (n60 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (ALU_b_in\<10\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U58 (n56 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (ALU_a_in\<11\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U56 (n54 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (ALU_b_in\<23\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U50 (n48 n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (ALU_b_in\<29\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U48 (n46 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (ALU_b_in\<18\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U43 (n41 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (ALU_b_in\<13\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n29 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (ALU_b_in\<19\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U28 (n26 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (ALU_b_in\<25\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (n24 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (ALU_b_in\<21\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U24 (n22 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (ALU_b_in\<30\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U80 (n34 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n34 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U548 (n295 n500 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U550 (n289 n502 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U552 (n283 n504 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U91 (n126 n90 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U87 (n152 n86 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U546 (n94 n498 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U538 (n120 n490 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U544 (n102 n496 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n542 rs2_out\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U15 (n540 rs2_out\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U3 (n538 rs2_out\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U16 (n532 rs2_out\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U32 (n530 rs2_out\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U8 (n526 rs2_out\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U7 (n522 rs2_out\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U38 (n520 rs2_out\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U33 (n518 rs2_out\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U17 (n516 rs2_out\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U20 (n570 rs2_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U18 (n512 rs2_out\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U5 (n508 rs2_out\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (n506 rs2_out\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U6 (n514 rs2_out\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U41 (n573 rs2_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U40 (n572 rs2_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U39 (n568 rs2_out\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U34 (n567 rs2_out\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U21 (n571 rs2_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U19 (n569 rs2_out\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U14 (n565 rs2_out\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U13 (n566 rs2_out\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U12 (n574 rs2_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U399 (n356 n357 n355 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U400 (n28 n546 n357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U154 (n70 n546 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U150 (n139 n138 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U404 (n361 n362 n360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U405 (n28 n547 n362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U162 (n70 n547 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U158 (n146 n145 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U416 (n373 n374 n372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U417 (n28 n548 n374 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U178 (n70 n548 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U174 (n159 n158 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U421 (n378 n379 n377 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U422 (n28 n549 n379 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U186 (n70 n549 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U182 (n166 n165 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U426 (n383 n384 n382 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U427 (n28 n550 n384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U194 (n70 n550 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U190 (n173 n172 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U431 (n388 n389 n387 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U432 (n28 n551 n389 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U202 (n70 n551 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U198 (n180 n179 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U436 (n393 n394 n392 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U437 (n28 n552 n394 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U210 (n70 n552 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U206 (n187 n186 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U535 (reg_a_src\<0\> n488 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U528 (n545 n52 n309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U525 (n480 n481 n479 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U442 (n28 n553 n399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U218 (n70 n553 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U214 (n194 n193 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U441 (n398 n399 n397 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U447 (n28 n554 n404 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U226 (n70 n554 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U222 (n200 n201 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U446 (n403 n404 n402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U452 (n28 n555 n409 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U234 (n70 n555 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U230 (n208 n207 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U451 (n408 n409 n407 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U457 (n28 n556 n414 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U242 (n70 n556 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U238 (n214 n215 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U456 (n413 n414 n412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U462 (n28 n557 n419 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U250 (n70 n557 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U246 (n222 n221 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U461 (n418 n419 n417 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U474 (n28 n558 n431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U266 (n70 n558 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n235 n234 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U473 (n430 n431 n429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U479 (n28 n559 n436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U274 (n70 n559 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U270 (n242 n241 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U478 (n435 n436 n434 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U484 (n28 n560 n441 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U282 (n70 n560 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U278 (n248 n249 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U483 (n440 n441 n439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U345 (n544 n21 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U489 (n28 n561 n446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U290 (n70 n561 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U286 (n256 n255 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U488 (n445 n446 n444 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U371 (n328 n329 n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U494 (n28 n562 n451 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U298 (n70 n562 n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U294 (n263 n262 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U493 (n450 n451 n449 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U499 (n28 n563 n456 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U306 (n70 n563 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U302 (n269 n270 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U498 (n455 n456 n454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U504 (n28 n564 n461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U314 (n70 n564 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U310 (n277 n276 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U503 (n460 n461 n459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U518 (n473 n474 n472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U350 (n305 n306 n304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U533 (reg_a_src\<1\> n53 n487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U385 (n342 n343 n341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U409 (n366 n367 n365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U357 (n314 n315 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U466 (n423 n424 n422 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U392 (n349 n350 n348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U378 (n335 n336 n334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U364 (n321 n322 n320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U347 (reg_b_src\<0\> n1 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    data_forwarder (rs1\<4\> rs1\<3\> rs1\<2\> rs1\<1\> rs1\<0\> rs2\<4\> \
        rs2\<3\> rs2\<2\> rs2\<1\> rs2\<0\> rs2_adr_mem\<4\> \
        rs2_adr_mem\<3\> rs2_adr_mem\<2\> rs2_adr_mem\<1\> \
        rs2_adr_mem\<0\> rd_dest_mem\<4\> rd_dest_mem\<3\> \
        rd_dest_mem\<2\> rd_dest_mem\<1\> rd_dest_mem\<0\> rd_dest_wb\<4\> \
        rd_dest_wb\<3\> rd_dest_wb\<2\> rd_dest_wb\<1\> rd_dest_wb\<0\> \
        rd_we_mem rd_we_wb mem_rs2_src reg_a_src\<1\> reg_a_src\<0\> \
        reg_b_src\<1\> reg_b_src\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_forwarder_schematic
    Arithmetic_logic_unit (n543 n541 n539 n537 n535 n533 n531 n529 n527 \
        n525 n523 n521 n519 n517 n515 n513 n511 n509 n507 ALU_a_in\<12\> \
        n57 n501 n499 n497 n495 n493 n491 n489 n89 n87 n85 n83 \
        ALU_b_in\<31\> n23 n49 ALU_b_in\<28\> ALU_b_in\<27\> \
        ALU_b_in\<26\> n27 ALU_b_in\<24\> n55 ALU_b_in\<22\> n25 \
        ALU_b_in\<20\> n30 n47 n63 ALU_b_in\<16\> ALU_b_in\<15\> \
        ALU_b_in\<14\> n42 ALU_b_in\<12\> ALU_b_in\<11\> n61 ALU_b_in\<9\> \
        ALU_b_in\<8\> ALU_b_in\<7\> ALU_b_in\<6\> ALU_b_in\<5\> \
        ALU_b_in\<4\> ALU_b_in\<3\> ALU_b_in\<2\> ALU_b_in\<1\> \
        ALU_b_in\<0\> ALU_operation\<3\> ALU_operation\<2\> \
        ALU_operation\<1\> ALU_operation\<0\> ALU_result\<31\> \
        ALU_result\<30\> ALU_result\<29\> ALU_result\<28\> \
        ALU_result\<27\> ALU_result\<26\> ALU_result\<25\> \
        ALU_result\<24\> ALU_result\<23\> ALU_result\<22\> \
        ALU_result\<21\> ALU_result\<20\> ALU_result\<19\> \
        ALU_result\<18\> ALU_result\<17\> ALU_result\<16\> \
        ALU_result\<15\> ALU_result\<14\> ALU_result\<13\> \
        ALU_result\<12\> ALU_result\<11\> ALU_result\<10\> ALU_result\<9\> \
        ALU_result\<8\> ALU_result\<7\> ALU_result\<6\> ALU_result\<5\> \
        ALU_result\<4\> ALU_result\<3\> ALU_result\<2\> ALU_result\<1\> \
        ALU_result\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_alu_schematic
ends soc_no_opt_16may_execute_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: branch_control
// View name: schematic
subckt soc_no_opt_16may_branch_control_schematic is_branch funct3\<2\> \
        funct3\<1\> funct3\<0\> ALU_result\<31\> ALU_result\<30\> \
        ALU_result\<29\> ALU_result\<28\> ALU_result\<27\> \
        ALU_result\<26\> ALU_result\<25\> ALU_result\<24\> \
        ALU_result\<23\> ALU_result\<22\> ALU_result\<21\> \
        ALU_result\<20\> ALU_result\<19\> ALU_result\<18\> \
        ALU_result\<17\> ALU_result\<16\> ALU_result\<15\> \
        ALU_result\<14\> ALU_result\<13\> ALU_result\<12\> \
        ALU_result\<11\> ALU_result\<10\> ALU_result\<9\> ALU_result\<8\> \
        ALU_result\<7\> ALU_result\<6\> ALU_result\<5\> ALU_result\<4\> \
        ALU_result\<3\> ALU_result\<2\> ALU_result\<1\> ALU_result\<0\> \
        branch inh_gnd inh_gnds inh_vdd inh_vdds
    U16 (funct3\<2\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n1 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n16 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (is_branch n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (funct3\<0\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (ALU_result\<28\> ALU_result\<29\> n45 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U48 (ALU_result\<2\> ALU_result\<30\> n46 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U43 (n41 n42 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U46 (ALU_result\<25\> ALU_result\<24\> n43 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U45 (ALU_result\<26\> ALU_result\<27\> n44 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U36 (n36 n35 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U19 (n17 n18 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U42 (ALU_result\<7\> ALU_result\<6\> n39 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U41 (ALU_result\<9\> ALU_result\<8\> n40 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U39 (ALU_result\<3\> ALU_result\<31\> n37 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U38 (ALU_result\<5\> ALU_result\<4\> n38 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U28 (n27 n28 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U21 (n21 n22 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U34 (ALU_result\<13\> ALU_result\<14\> n31 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U33 (ALU_result\<15\> ALU_result\<16\> n32 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U31 (ALU_result\<10\> ALU_result\<0\> n29 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U30 (ALU_result\<11\> ALU_result\<12\> n30 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U27 (ALU_result\<20\> ALU_result\<21\> n25 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U26 (ALU_result\<22\> ALU_result\<23\> n26 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U24 (ALU_result\<18\> ALU_result\<17\> n23 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U23 (ALU_result\<1\> ALU_result\<19\> n24 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2 (funct3\<1\> n10 n2 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5 (N88 n13 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U4 (funct3\<0\> n12 n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6 (n5 n6 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U17 (n15 n11 N88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U47 (n45 n46 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n43 n44 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n33 n34 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n40 n39 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n37 n38 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (n19 n20 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n31 n32 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n29 n30 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n25 n26 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n23 n24 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3 (n3 n4 branch inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (n9 funct3\<2\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (n14 n2 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U8 (n12 funct3\<0\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7 (n13 N88 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U9 (n8 n7 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U18 (is_branch n15 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends soc_no_opt_16may_branch_control_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: memory
// View name: schematic
subckt soc_no_opt_16may_memory_schematic clk ALU_result\<31\> \
        ALU_result\<30\> ALU_result\<29\> ALU_result\<28\> \
        ALU_result\<27\> ALU_result\<26\> ALU_result\<25\> \
        ALU_result\<24\> ALU_result\<23\> ALU_result\<22\> \
        ALU_result\<21\> ALU_result\<20\> ALU_result\<19\> \
        ALU_result\<18\> ALU_result\<17\> ALU_result\<16\> \
        ALU_result\<15\> ALU_result\<14\> ALU_result\<13\> \
        ALU_result\<12\> ALU_result\<11\> ALU_result\<10\> ALU_result\<9\> \
        ALU_result\<8\> ALU_result\<7\> ALU_result\<6\> ALU_result\<5\> \
        ALU_result\<4\> ALU_result\<3\> ALU_result\<2\> ALU_result\<1\> \
        ALU_result\<0\> rs2_data_ex\<31\> rs2_data_ex\<30\> \
        rs2_data_ex\<29\> rs2_data_ex\<28\> rs2_data_ex\<27\> \
        rs2_data_ex\<26\> rs2_data_ex\<25\> rs2_data_ex\<24\> \
        rs2_data_ex\<23\> rs2_data_ex\<22\> rs2_data_ex\<21\> \
        rs2_data_ex\<20\> rs2_data_ex\<19\> rs2_data_ex\<18\> \
        rs2_data_ex\<17\> rs2_data_ex\<16\> rs2_data_ex\<15\> \
        rs2_data_ex\<14\> rs2_data_ex\<13\> rs2_data_ex\<12\> \
        rs2_data_ex\<11\> rs2_data_ex\<10\> rs2_data_ex\<9\> \
        rs2_data_ex\<8\> rs2_data_ex\<7\> rs2_data_ex\<6\> \
        rs2_data_ex\<5\> rs2_data_ex\<4\> rs2_data_ex\<3\> \
        rs2_data_ex\<2\> rs2_data_ex\<1\> rs2_data_ex\<0\> \
        rs2_data_wb\<31\> rs2_data_wb\<30\> rs2_data_wb\<29\> \
        rs2_data_wb\<28\> rs2_data_wb\<27\> rs2_data_wb\<26\> \
        rs2_data_wb\<25\> rs2_data_wb\<24\> rs2_data_wb\<23\> \
        rs2_data_wb\<22\> rs2_data_wb\<21\> rs2_data_wb\<20\> \
        rs2_data_wb\<19\> rs2_data_wb\<18\> rs2_data_wb\<17\> \
        rs2_data_wb\<16\> rs2_data_wb\<15\> rs2_data_wb\<14\> \
        rs2_data_wb\<13\> rs2_data_wb\<12\> rs2_data_wb\<11\> \
        rs2_data_wb\<10\> rs2_data_wb\<9\> rs2_data_wb\<8\> \
        rs2_data_wb\<7\> rs2_data_wb\<6\> rs2_data_wb\<5\> \
        rs2_data_wb\<4\> rs2_data_wb\<3\> rs2_data_wb\<2\> \
        rs2_data_wb\<1\> rs2_data_wb\<0\> rs2_src mem_write_width\<1\> \
        mem_write_width\<0\> mem_we mem_re is_branch funct3\<2\> \
        funct3\<1\> funct3\<0\> is_jump new_PC\<10\> new_PC\<9\> \
        new_PC\<8\> new_PC\<7\> new_PC\<6\> new_PC\<5\> new_PC\<4\> \
        new_PC\<3\> new_PC\<2\> new_PC\<1\> new_PC\<0\> \
        branch_target\<10\> branch_target\<9\> branch_target\<8\> \
        branch_target\<7\> branch_target\<6\> branch_target\<5\> \
        branch_target\<4\> branch_target\<3\> branch_target\<2\> \
        branch_target\<1\> branch_target\<0\> control_transfer branched \
        PC_incr\<10\> PC_incr\<9\> PC_incr\<8\> PC_incr\<7\> PC_incr\<6\> \
        PC_incr\<5\> PC_incr\<4\> PC_incr\<3\> PC_incr\<2\> PC_incr\<1\> \
        PC_incr\<0\> branch_out bram_mem_be\<1\> bram_mem_be\<0\> \
        bram_addr\<11\> bram_addr\<10\> bram_addr\<9\> bram_addr\<8\> \
        bram_addr\<7\> bram_addr\<6\> bram_addr\<5\> bram_addr\<4\> \
        bram_addr\<3\> bram_addr\<2\> bram_addr\<1\> bram_addr\<0\> \
        bram_we bram_re bram_data_in\<31\> bram_data_in\<30\> \
        bram_data_in\<29\> bram_data_in\<28\> bram_data_in\<27\> \
        bram_data_in\<26\> bram_data_in\<25\> bram_data_in\<24\> \
        bram_data_in\<23\> bram_data_in\<22\> bram_data_in\<21\> \
        bram_data_in\<20\> bram_data_in\<19\> bram_data_in\<18\> \
        bram_data_in\<17\> bram_data_in\<16\> bram_data_in\<15\> \
        bram_data_in\<14\> bram_data_in\<13\> bram_data_in\<12\> \
        bram_data_in\<11\> bram_data_in\<10\> bram_data_in\<9\> \
        bram_data_in\<8\> bram_data_in\<7\> bram_data_in\<6\> \
        bram_data_in\<5\> bram_data_in\<4\> bram_data_in\<3\> \
        bram_data_in\<2\> bram_data_in\<1\> bram_data_in\<0\> inh_gnd \
        inh_gnds inh_vdd_rename inh_vdds
    Vmemory (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    Thru27 (mem_re bram_re) iprobe
    Thru26 (mem_we bram_we) iprobe
    Thru25 (ALU_result\<0\> ALU_result\[0\]) iprobe
    Thru23 (ALU_result\<1\> ALU_result\[1\]) iprobe
    Thru21 (ALU_result\<2\> ALU_result\[2\]) iprobe
    Thru19 (ALU_result\<3\> ALU_result\[3\]) iprobe
    Thru17 (ALU_result\<4\> ALU_result\[4\]) iprobe
    Thru15 (ALU_result\<5\> ALU_result\[5\]) iprobe
    Thru13 (ALU_result\<6\> ALU_result\[6\]) iprobe
    Thru11 (ALU_result\<7\> ALU_result\[7\]) iprobe
    Thru9 (ALU_result\<8\> ALU_result\[8\]) iprobe
    Thru7 (ALU_result\<9\> ALU_result\[9\]) iprobe
    Thru5 (ALU_result\<10\> ALU_result\[10\]) iprobe
    Thru3 (ALU_result\<11\> ALU_result\[11\]) iprobe
    Thru24 (ALU_result\[0\] bram_addr\<0\>) iprobe
    Thru22 (ALU_result\[1\] bram_addr\<1\>) iprobe
    Thru20 (ALU_result\[2\] bram_addr\<2\>) iprobe
    Thru18 (ALU_result\[3\] bram_addr\<3\>) iprobe
    Thru16 (ALU_result\[4\] bram_addr\<4\>) iprobe
    Thru14 (ALU_result\[5\] bram_addr\<5\>) iprobe
    Thru12 (ALU_result\[6\] bram_addr\<6\>) iprobe
    Thru10 (ALU_result\[7\] bram_addr\<7\>) iprobe
    Thru8 (ALU_result\[8\] bram_addr\<8\>) iprobe
    Thru6 (ALU_result\[9\] bram_addr\<9\>) iprobe
    Thru4 (ALU_result\[10\] bram_addr\<10\>) iprobe
    Thru2 (ALU_result\[11\] bram_addr\<11\>) iprobe
    Thru1 (mem_write_width\<0\> bram_mem_be\<0\>) iprobe
    Thru0 (mem_write_width\<1\> bram_mem_be\<1\>) iprobe
    U74 (n63 is_branch n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n62 n12 control_transfer inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n144 branch_out n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (branched n143 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n64 n65 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (ALU_result\[3\] n13 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n139 n42 new_PC\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (branch_target\<3\> n7 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n10 PC_incr\<3\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n44 n45 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n4 ALU_result\[6\] n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n136 n30 new_PC\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (PC_incr\<6\> n10 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (branch_target\<6\> n7 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n32 n33 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (PC_incr\<0\> n1 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (branch_target\<0\> n7 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n142 n58 new_PC\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n5 ALU_result\[0\] n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n60 n61 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (PC_incr\<10\> n1 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (branch_target\<10\> n7 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n132 n54 new_PC\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (ALU_result\[10\] n5 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n56 n57 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (rs2_data_wb\<0\> rs2_src n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n128 n129 bram_data_in\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (rs2_data_ex\<0\> n131 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (rs2_data_wb\<10\> rs2_src n126 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U168 (n126 n127 bram_data_in\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (rs2_data_ex\<10\> n131 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n8 rs2_data_wb\<11\> n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n125 n124 bram_data_in\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (rs2_data_ex\<11\> n131 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n15 rs2_data_wb\<12\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n122 n123 bram_data_in\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (rs2_data_ex\<12\> n131 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n15 rs2_data_wb\<13\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n120 n121 bram_data_in\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (rs2_data_ex\<13\> n131 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n11 rs2_data_wb\<14\> n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n118 n119 bram_data_in\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (rs2_data_ex\<14\> n131 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (rs2_data_wb\<15\> rs2_src n116 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U153 (n116 n117 bram_data_in\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (rs2_data_ex\<15\> n131 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n8 rs2_data_wb\<16\> n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n115 n114 bram_data_in\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (rs2_data_ex\<16\> n131 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n130 rs2_data_wb\<17\> n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n112 n113 bram_data_in\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (rs2_data_ex\<17\> n131 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (rs2_data_wb\<18\> n11 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n110 n111 bram_data_in\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (rs2_data_ex\<18\> n131 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n130 rs2_data_wb\<19\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n108 n109 bram_data_in\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (rs2_data_ex\<19\> n131 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (rs2_data_wb\<1\> n11 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n106 n107 bram_data_in\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (rs2_data_ex\<1\> n131 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n130 rs2_data_wb\<20\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n104 n105 bram_data_in\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (rs2_data_ex\<20\> n131 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n11 rs2_data_wb\<21\> n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n102 n103 bram_data_in\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (rs2_data_ex\<21\> n131 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (rs2_src rs2_data_wb\<22\> n100 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U129 (n100 n101 bram_data_in\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (rs2_data_ex\<22\> n131 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n15 rs2_data_wb\<23\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n98 n99 bram_data_in\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (rs2_data_ex\<23\> n131 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n8 rs2_data_wb\<24\> n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n97 n96 bram_data_in\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (rs2_data_ex\<24\> n131 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n15 rs2_data_wb\<25\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n94 n95 bram_data_in\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (rs2_data_ex\<25\> n131 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n130 rs2_data_wb\<26\> n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n92 n93 bram_data_in\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (rs2_data_ex\<26\> n131 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n8 rs2_data_wb\<27\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n91 n90 bram_data_in\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (rs2_data_ex\<27\> n131 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n8 rs2_data_wb\<28\> n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n89 n88 bram_data_in\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (rs2_data_ex\<28\> n131 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n11 rs2_data_wb\<29\> n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n86 n87 bram_data_in\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (rs2_data_ex\<29\> n131 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n11 rs2_data_wb\<30\> n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n82 n83 bram_data_in\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (rs2_data_ex\<30\> n131 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (rs2_data_wb\<2\> rs2_src n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n84 n85 bram_data_in\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (rs2_data_ex\<2\> n131 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (rs2_src rs2_data_wb\<31\> n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n80 n81 bram_data_in\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (rs2_data_ex\<31\> n131 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (rs2_data_wb\<3\> rs2_src n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n78 n79 bram_data_in\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (rs2_data_ex\<3\> n131 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (rs2_data_wb\<4\> rs2_src n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n76 n77 bram_data_in\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (rs2_data_ex\<4\> n131 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (rs2_data_wb\<6\> rs2_src n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n72 n73 bram_data_in\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (rs2_data_ex\<6\> n131 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (rs2_data_wb\<5\> n15 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n74 n75 bram_data_in\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (rs2_data_ex\<5\> n131 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (rs2_data_wb\<8\> n15 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n68 n69 bram_data_in\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (rs2_data_ex\<8\> n131 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (rs2_data_wb\<7\> n130 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n70 n71 bram_data_in\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (rs2_data_ex\<7\> n131 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (rs2_data_wb\<9\> n130 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (n66 n67 bram_data_in\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (rs2_data_ex\<9\> n131 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n5 ALU_result\[4\] n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n138 n38 new_PC\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (PC_incr\<1\> n1 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n141 n50 new_PC\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (ALU_result\[1\] n2 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (branch_target\<1\> n7 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n52 n53 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (branch_target\<2\> n7 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n140 n46 new_PC\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (ALU_result\[2\] n2 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n10 PC_incr\<2\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n48 n49 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (ALU_result\[7\] n2 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n135 n26 new_PC\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (PC_incr\<7\> n1 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (branch_target\<7\> n7 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n28 n29 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (PC_incr\<9\> n10 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (branch_target\<9\> n7 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (n133 n16 new_PC\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (n14 ALU_result\[9\] n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (n18 n19 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (PC_incr\<5\> n1 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (branch_target\<5\> n7 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n137 n34 new_PC\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (ALU_result\[5\] n14 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n36 n37 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (PC_incr\<8\> n1 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (branch_target\<8\> n7 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U21 (n134 n22 new_PC\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n14 ALU_result\[8\] n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (n24 n25 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n10 PC_incr\<4\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n40 n41 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (branch_target\<4\> n7 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3 (n143 branch_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U188 (branched n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U183 (n43 n139 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U180 (n31 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U186 (n59 n142 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U176 (n55 n132 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n20 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n6 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U182 (n39 n138 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n21 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (is_jump n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U187 (n145 n143 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n12 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n12 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n9 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n9 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U175 (rs2_src n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U174 (n131 n130 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n131 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n12 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n131 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n131 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n12 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n12 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U185 (n51 n141 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U184 (n47 n140 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U179 (n27 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U177 (n17 n133 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U181 (n35 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U178 (n23 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (n143 n4 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n145 n13 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    branch_control (is_branch funct3\<2\> funct3\<1\> funct3\<0\> \
        ALU_result\<31\> ALU_result\<30\> ALU_result\<29\> \
        ALU_result\<28\> ALU_result\<27\> ALU_result\<26\> \
        ALU_result\<25\> ALU_result\<24\> ALU_result\<23\> \
        ALU_result\<22\> ALU_result\<21\> ALU_result\<20\> \
        ALU_result\<19\> ALU_result\<18\> ALU_result\<17\> \
        ALU_result\<16\> ALU_result\<15\> ALU_result\<14\> \
        ALU_result\<13\> ALU_result\<12\> ALU_result\[11\] \
        ALU_result\[10\] ALU_result\[9\] ALU_result\[8\] ALU_result\[7\] \
        ALU_result\[6\] ALU_result\[5\] ALU_result\[4\] ALU_result\[3\] \
        ALU_result\[2\] ALU_result\[1\] ALU_result\[0\] n145 inh_gnd \
        inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_branch_control_schematic
ends soc_no_opt_16may_memory_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: activity_control
// View name: schematic
subckt soc_no_opt_16may_activity_control_schematic clk sleep stall_ID \
        nreset control_transfer_MEM init_sleep counter_enable stall_IF \
        stall flush_IFID flush_IDEX flush_EXMEM flush_MEMWB inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U18 (sleep counter_enable inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (nreset flush_MEMWB inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n13 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n7 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n12 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n9 stall inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n1 flush_EXMEM inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n1 flush_IFID inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (nreset n6 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9 (n1 n9 flush_IDEX inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U13 (control_transfer_MEM sleep n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7 (control_transfer_MEM n9 stall_IF inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U14 (counter_enable flush_MEMWB N2 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U11 (stall_ID n4 n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U10 (n5 flush_MEMWB n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U8 (counter_enable n4 init_sleep inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    sleeping_reg (clk N2 NeTt_46 n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
ends soc_no_opt_16may_activity_control_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: IFID_preg
// View name: schematic
subckt soc_no_opt_16may_IFID_preg_schematic clk flush stall \
        instruction_i\<31\> instruction_i\<30\> instruction_i\<29\> \
        instruction_i\<28\> instruction_i\<27\> instruction_i\<26\> \
        instruction_i\<25\> instruction_i\<24\> instruction_i\<23\> \
        instruction_i\<22\> instruction_i\<21\> instruction_i\<20\> \
        instruction_i\<19\> instruction_i\<18\> instruction_i\<17\> \
        instruction_i\<16\> instruction_i\<15\> instruction_i\<14\> \
        instruction_i\<13\> instruction_i\<12\> instruction_i\<11\> \
        instruction_i\<10\> instruction_i\<9\> instruction_i\<8\> \
        instruction_i\<7\> instruction_i\<6\> instruction_i\<5\> \
        instruction_i\<4\> instruction_i\<3\> instruction_i\<2\> \
        instruction_i\<1\> instruction_i\<0\> branch_target_in\<10\> \
        branch_target_in\<9\> branch_target_in\<8\> branch_target_in\<7\> \
        branch_target_in\<6\> branch_target_in\<5\> branch_target_in\<4\> \
        branch_target_in\<3\> branch_target_in\<2\> branch_target_in\<1\> \
        branch_target_in\<0\> branch_target_out\<10\> \
        branch_target_out\<9\> branch_target_out\<8\> \
        branch_target_out\<7\> branch_target_out\<6\> \
        branch_target_out\<5\> branch_target_out\<4\> \
        branch_target_out\<3\> branch_target_out\<2\> \
        branch_target_out\<1\> branch_target_out\<0\> instruction_o\<31\> \
        instruction_o\<30\> instruction_o\<29\> instruction_o\<28\> \
        instruction_o\<27\> instruction_o\<26\> instruction_o\<25\> \
        instruction_o\<24\> instruction_o\<23\> instruction_o\<22\> \
        instruction_o\<21\> instruction_o\<20\> instruction_o\<19\> \
        instruction_o\<18\> instruction_o\<17\> instruction_o\<16\> \
        instruction_o\<15\> instruction_o\<14\> instruction_o\<13\> \
        instruction_o\<12\> instruction_o\<11\> instruction_o\<10\> \
        instruction_o\<9\> instruction_o\<8\> instruction_o\<7\> \
        instruction_o\<6\> instruction_o\<5\> instruction_o\<4\> \
        instruction_o\<3\> instruction_o\<2\> instruction_o\<1\> \
        instruction_o\<0\> current_PC_in\<10\> current_PC_in\<9\> \
        current_PC_in\<8\> current_PC_in\<7\> current_PC_in\<6\> \
        current_PC_in\<5\> current_PC_in\<4\> current_PC_in\<3\> \
        current_PC_in\<2\> current_PC_in\<1\> current_PC_in\<0\> \
        current_PC_out\<10\> current_PC_out\<9\> current_PC_out\<8\> \
        current_PC_out\<7\> current_PC_out\<6\> current_PC_out\<5\> \
        current_PC_out\<4\> current_PC_out\<3\> current_PC_out\<2\> \
        current_PC_out\<1\> current_PC_out\<0\> PC_incr_in\<10\> \
        PC_incr_in\<9\> PC_incr_in\<8\> PC_incr_in\<7\> PC_incr_in\<6\> \
        PC_incr_in\<5\> PC_incr_in\<4\> PC_incr_in\<3\> PC_incr_in\<2\> \
        PC_incr_in\<1\> PC_incr_in\<0\> PC_incr_out\<10\> PC_incr_out\<9\> \
        PC_incr_out\<8\> PC_incr_out\<7\> PC_incr_out\<6\> \
        PC_incr_out\<5\> PC_incr_out\<4\> PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> branched_in \
        branched_out inh_gnd inh_gnds inh_vdd inh_vdds
    U4 (n353 n255 n1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3 (n350 PC_incr_in\<0\> n2 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2 (n1 n2 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U112 (n233 instruction_o\<2\> n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n273 instruction_i\<2\> n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n76 n77 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n233 instruction_o\<24\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (instruction_i\<24\> n202 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n120 n121 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (instruction_i\<19\> n202 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n3 instruction_o\<19\> n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n110 n111 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n240 instruction_o\<21\> n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (instruction_i\<21\> n274 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n114 n115 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (instruction_o\<16\> n3 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (instruction_i\<16\> n273 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n104 n105 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n240 instruction_o\<14\> n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (instruction_i\<14\> n202 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n100 n101 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n233 instruction_o\<31\> n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (instruction_i\<31\> n237 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n134 n135 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n3 instruction_o\<26\> n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (instruction_i\<26\> n273 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n124 n125 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (instruction_o\<28\> n343 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (n274 instruction_i\<28\> n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n128 n129 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (instruction_o\<1\> n232 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (instruction_i\<1\> n274 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n74 n75 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n345 instruction_o\<18\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (instruction_i\<18\> n70 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n108 n109 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n343 instruction_o\<23\> n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (instruction_i\<23\> n274 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n118 n119 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n232 instruction_o\<4\> n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (instruction_i\<4\> n273 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n80 n81 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n345 instruction_o\<13\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (instruction_i\<13\> n237 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n98 n99 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n240 instruction_o\<15\> n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (instruction_i\<15\> n274 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n102 n103 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n343 instruction_o\<25\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (instruction_i\<25\> n70 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n122 n123 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n232 instruction_o\<0\> n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (instruction_i\<0\> n202 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n72 n73 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n345 instruction_o\<8\> n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (instruction_i\<8\> n274 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n88 n89 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (instruction_i\<7\> n274 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n344 instruction_o\<7\> n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n86 n87 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n343 instruction_o\<10\> n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (instruction_i\<10\> n70 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n92 n93 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (instruction_o\<12\> n343 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (instruction_i\<12\> n237 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n96 n97 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n345 instruction_o\<9\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (instruction_i\<9\> n70 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n90 n91 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n345 branched_out n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (branched_in n273 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n68 n69 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n344 instruction_o\<22\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (instruction_i\<22\> n202 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n116 n117 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n240 instruction_o\<17\> n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (instruction_i\<17\> n237 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n106 n107 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n240 instruction_o\<29\> n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7 (n246 n253 n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6 (n351 PC_incr_in\<1\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5 (n4 n5 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U115 (n71 instruction_o\<3\> n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n237 instruction_i\<3\> n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n78 n79 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n232 instruction_o\<27\> n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (instruction_i\<5\> n70 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n82 n83 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n273 instruction_i\<27\> n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (instruction_i\<20\> n273 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n126 n127 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n344 instruction_o\<20\> n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n112 n113 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (instruction_o\<11\> n344 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (instruction_i\<11\> n237 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n95 n94 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (instruction_i\<30\> n237 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n344 instruction_o\<30\> n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n132 n133 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (PC_incr_in\<10\> n349 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n353 n318 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n22 n23 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (n349 PC_incr_in\<9\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n320 n352 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n20 n21 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n351 PC_incr_in\<8\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n353 n322 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n18 n19 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (PC_incr_in\<5\> n351 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (n353 n328 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (n12 n13 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n353 n314 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (current_PC_in\<3\> n351 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n30 n31 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (current_PC_in\<10\> n351 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n352 n304 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n44 n45 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n351 current_PC_in\<7\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n352 n310 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n38 n39 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n352 n266 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (branch_target_in\<10\> n349 n67 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U98 (n66 n67 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (branch_target_in\<9\> n349 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (stall n286 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n64 n65 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (branch_target_in\<8\> n349 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n288 n246 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n62 n63 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (branch_target_in\<0\> n349 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n245 n251 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n46 n47 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (branch_target_in\<6\> n351 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n246 n292 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n58 n59 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (branch_target_in\<5\> n351 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n348 n294 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (n56 n57 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9 (n351 PC_incr_in\<2\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (n245 n239 n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U8 (n6 n7 n138 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U13 (n245 n332 n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U12 (PC_incr_in\<3\> n354 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (n8 n9 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n233 instruction_o\<6\> n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n84 n85 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n233 instruction_o\<5\> n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n202 instruction_i\<29\> n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n130 n131 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (instruction_i\<6\> n202 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (n246 n330 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U15 (PC_incr_in\<4\> n354 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U14 (n10 n11 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n326 stall n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U21 (PC_incr_in\<6\> n350 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (n14 n15 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (PC_incr_in\<7\> n350 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n246 n324 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (n16 n17 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n270 n246 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n354 current_PC_in\<4\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n32 n33 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n316 n246 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n354 current_PC_in\<2\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n28 n29 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (current_PC_in\<9\> n354 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (stall n306 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n42 n43 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n354 current_PC_in\<8\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (stall n308 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n40 n41 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n298 stall n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (branch_target_in\<3\> n350 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n52 n53 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (branch_target_in\<7\> n354 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n348 n290 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n60 n61 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (current_PC_in\<5\> n354 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n348 n268 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n34 n35 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (branch_target_in\<4\> n350 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n245 n296 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n54 n55 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (branch_target_in\<2\> n350 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n245 n300 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n50 n51 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (branch_target_in\<1\> n350 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n348 n302 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (n48 n49 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n245 n312 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (current_PC_in\<6\> n350 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n36 n37 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (current_PC_in\<1\> n350 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n242 n348 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n26 n27 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (current_PC_in\<0\> n350 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n24 n25 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n348 n244 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n254 n255 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U285 (n353 n350 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U277 (n225 instruction_o\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U276 (n220 instruction_o\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U275 (n229 instruction_o\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U274 (n212 instruction_o\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U273 (n224 instruction_o\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U272 (n209 instruction_o\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U271 (n234 instruction_o\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U270 (n218 instruction_o\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U269 (n204 instruction_o\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U268 (n214 instruction_o\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U243 (n211 instruction_o\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U242 (n228 instruction_o\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U241 (n223 instruction_o\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U240 (n226 instruction_o\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U239 (n230 instruction_o\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U238 (n219 instruction_o\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U237 (n213 instruction_o\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U236 (n216 instruction_o\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U220 (n215 instruction_o\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U235 (n207 instruction_o\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U214 (n227 instruction_o\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U234 (n217 instruction_o\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U231 (n272 branched_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U227 (n203 instruction_o\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U226 (n210 instruction_o\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U288 (n349 n353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U284 (n352 n349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U287 (n354 n352 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U289 (stall n354 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U286 (n352 n351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U283 (n354 n348 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U202 (n346 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U208 (n346 n240 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U205 (n346 n233 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U281 (n71 n346 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U280 (n346 n345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U279 (n346 n344 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U278 (n346 n343 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U204 (n346 n232 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U282 (n70 n347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U233 (n347 n274 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U232 (n347 n273 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U206 (n347 n237 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U203 (n347 n202 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U217 (n252 n253 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U225 (n221 instruction_o\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U223 (n236 instruction_o\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U221 (n235 instruction_o\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U224 (n222 instruction_o\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U219 (n208 instruction_o\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U213 (n206 instruction_o\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U260 (n317 n318 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U261 (n319 n320 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U262 (n321 n322 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U265 (n327 n328 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U258 (n313 n314 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U253 (n303 n304 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U256 (n309 n310 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U228 (n265 n266 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U244 (n285 n286 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U245 (n287 n288 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U216 (n250 n251 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U247 (n291 n292 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U248 (n293 n294 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U207 (n238 n239 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U267 (n331 n332 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U215 (n231 instruction_o\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U222 (n205 instruction_o\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U212 (n351 n246 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U211 (n349 n245 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U266 (n329 n330 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U264 (n325 n326 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U263 (n323 n324 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U230 (n269 n270 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U259 (n315 n316 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U254 (n305 n306 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U255 (n307 n308 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U250 (n297 n298 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U246 (n289 n290 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U229 (n267 n268 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U249 (n295 n296 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U251 (n299 n300 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U252 (n301 n302 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U257 (n311 n312 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U209 (n241 n242 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U210 (n243 n244 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    PC_incr_reg_0_ (clk n136 PC_incr_out\<0\> n254 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_2_ (clk n172 NeTt_992 n225 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_24_ (clk n194 NeTt_993 n220 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_19_ (clk n189 NeTt_994 n229 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_21_ (clk n191 NeTt_995 n212 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_16_ (clk n186 NeTt_996 n224 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_14_ (clk n184 NeTt_997 n209 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_31_ (clk n201 NeTt_998 n234 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_26_ (clk n196 NeTt_999 n218 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_28_ (clk n198 NeTt_1000 n204 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_1_ (clk n171 NeTt_1001 n214 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_18_ (clk n188 NeTt_1002 n211 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_23_ (clk n193 NeTt_1003 n228 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_4_ (clk n174 NeTt_1004 n223 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_13_ (clk n183 NeTt_1005 n226 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_15_ (clk n185 NeTt_1006 n230 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_25_ (clk n195 NeTt_1007 n219 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_0_ (clk n170 NeTt_1008 n213 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_8_ (clk n178 NeTt_1009 n216 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_7_ (clk n177 NeTt_1010 n215 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_10_ (clk n180 NeTt_1011 n207 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_12_ (clk n182 NeTt_1012 n227 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_9_ (clk n179 NeTt_1013 n217 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branched_reg (clk n169 NeTt_1014 n272 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_22_ (clk n192 NeTt_1015 n203 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_17_ (clk n187 NeTt_1016 n210 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_1_ (clk n137 PC_incr_out\<1\> n252 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_3_ (clk n173 NeTt_1017 n221 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_5_ (clk n175 NeTt_1018 n236 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_27_ (clk n197 NeTt_1019 n235 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_20_ (clk n190 NeTt_1020 n222 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_11_ (clk n181 NeTt_1021 n208 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_30_ (clk n200 NeTt_1022 n206 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_10_ (clk n146 PC_incr_out\<10\> n317 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_9_ (clk n145 PC_incr_out\<9\> n319 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_8_ (clk n144 PC_incr_out\<8\> n321 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_5_ (clk n141 PC_incr_out\<5\> n327 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_3_ (clk n150 current_PC_out\<3\> n313 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_10_ (clk n157 current_PC_out\<10\> n303 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_7_ (clk n154 current_PC_out\<7\> n309 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_10_ (clk n168 branch_target_out\<10\> n265 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_9_ (clk n167 branch_target_out\<9\> n285 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_8_ (clk n166 branch_target_out\<8\> n287 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_0_ (clk n158 branch_target_out\<0\> n250 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_6_ (clk n164 branch_target_out\<6\> n291 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_5_ (clk n163 branch_target_out\<5\> n293 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_2_ (clk n138 PC_incr_out\<2\> n238 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_3_ (clk n139 PC_incr_out\<3\> n331 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_6_ (clk n176 NeTt_1023 n231 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instruction_reg_29_ (clk n199 NeTt_1024 n205 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_4_ (clk n140 PC_incr_out\<4\> n329 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_6_ (clk n142 PC_incr_out\<6\> n325 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_reg_7_ (clk n143 PC_incr_out\<7\> n323 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_4_ (clk n151 current_PC_out\<4\> n269 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_2_ (clk n149 current_PC_out\<2\> n315 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_9_ (clk n156 current_PC_out\<9\> n305 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_8_ (clk n155 current_PC_out\<8\> n307 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_3_ (clk n161 branch_target_out\<3\> n297 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_7_ (clk n165 branch_target_out\<7\> n289 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_5_ (clk n152 current_PC_out\<5\> n267 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_4_ (clk n162 branch_target_out\<4\> n295 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_2_ (clk n160 branch_target_out\<2\> n299 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_reg_1_ (clk n159 branch_target_out\<1\> n301 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_6_ (clk n153 current_PC_out\<6\> n311 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_1_ (clk n148 current_PC_out\<1\> n241 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_reg_0_ (clk n147 current_PC_out\<0\> n243 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U201 (n349 flush n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U199 (n232 flush n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_IFID_preg_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: write_back
// View name: schematic
subckt soc_no_opt_16may_write_back_schematic wb_src\<1\> wb_src\<0\> \
        mem_data\<31\> mem_data\<30\> mem_data\<29\> mem_data\<28\> \
        mem_data\<27\> mem_data\<26\> mem_data\<25\> mem_data\<24\> \
        mem_data\<23\> mem_data\<22\> mem_data\<21\> mem_data\<20\> \
        mem_data\<19\> mem_data\<18\> mem_data\<17\> mem_data\<16\> \
        mem_data\<15\> mem_data\<14\> mem_data\<13\> mem_data\<12\> \
        mem_data\<11\> mem_data\<10\> mem_data\<9\> mem_data\<8\> \
        mem_data\<7\> mem_data\<6\> mem_data\<5\> mem_data\<4\> \
        mem_data\<3\> mem_data\<2\> mem_data\<1\> mem_data\<0\> \
        ALU_data\<31\> ALU_data\<30\> ALU_data\<29\> ALU_data\<28\> \
        ALU_data\<27\> ALU_data\<26\> ALU_data\<25\> ALU_data\<24\> \
        ALU_data\<23\> ALU_data\<22\> ALU_data\<21\> ALU_data\<20\> \
        ALU_data\<19\> ALU_data\<18\> ALU_data\<17\> ALU_data\<16\> \
        ALU_data\<15\> ALU_data\<14\> ALU_data\<13\> ALU_data\<12\> \
        ALU_data\<11\> ALU_data\<10\> ALU_data\<9\> ALU_data\<8\> \
        ALU_data\<7\> ALU_data\<6\> ALU_data\<5\> ALU_data\<4\> \
        ALU_data\<3\> ALU_data\<2\> ALU_data\<1\> ALU_data\<0\> \
        wb_data\<31\> wb_data\<30\> wb_data\<29\> wb_data\<28\> \
        wb_data\<27\> wb_data\<26\> wb_data\<25\> wb_data\<24\> \
        wb_data\<23\> wb_data\<22\> wb_data\<21\> wb_data\<20\> \
        wb_data\<19\> wb_data\<18\> wb_data\<17\> wb_data\<16\> \
        wb_data\<15\> wb_data\<14\> wb_data\<13\> wb_data\<12\> \
        wb_data\<11\> wb_data\<10\> wb_data\<9\> wb_data\<8\> wb_data\<7\> \
        wb_data\<6\> wb_data\<5\> wb_data\<4\> wb_data\<3\> wb_data\<2\> \
        wb_data\<1\> wb_data\<0\> mem_load_width\<1\> mem_load_width\<0\> \
        mem_load_unsigned PC_incr\<10\> PC_incr\<9\> PC_incr\<8\> \
        PC_incr\<7\> PC_incr\<6\> PC_incr\<5\> PC_incr\<4\> PC_incr\<3\> \
        PC_incr\<2\> PC_incr\<1\> PC_incr\<0\> clock_count\<63\> \
        clock_count\<62\> clock_count\<61\> clock_count\<60\> \
        clock_count\<59\> clock_count\<58\> clock_count\<57\> \
        clock_count\<56\> clock_count\<55\> clock_count\<54\> \
        clock_count\<53\> clock_count\<52\> clock_count\<51\> \
        clock_count\<50\> clock_count\<49\> clock_count\<48\> \
        clock_count\<47\> clock_count\<46\> clock_count\<45\> \
        clock_count\<44\> clock_count\<43\> clock_count\<42\> \
        clock_count\<41\> clock_count\<40\> clock_count\<39\> \
        clock_count\<38\> clock_count\<37\> clock_count\<36\> \
        clock_count\<35\> clock_count\<34\> clock_count\<33\> \
        clock_count\<32\> clock_count\<31\> clock_count\<30\> \
        clock_count\<29\> clock_count\<28\> clock_count\<27\> \
        clock_count\<26\> clock_count\<25\> clock_count\<24\> \
        clock_count\<23\> clock_count\<22\> clock_count\<21\> \
        clock_count\<20\> clock_count\<19\> clock_count\<18\> \
        clock_count\<17\> clock_count\<16\> clock_count\<15\> \
        clock_count\<14\> clock_count\<13\> clock_count\<12\> \
        clock_count\<11\> clock_count\<10\> clock_count\<9\> \
        clock_count\<8\> clock_count\<7\> clock_count\<6\> \
        clock_count\<5\> clock_count\<4\> clock_count\<3\> \
        clock_count\<2\> clock_count\<1\> clock_count\<0\> inh_gnd \
        inh_gnds inh_vdd_rename inh_vdds
    Vwrite_back (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    U94 (n19 n102 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (ALU_data\<31\> n9 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (clock_count\<31\> n7 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (mem_data\<31\> n5 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n103 n104 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n109 n14 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (ALU_data\<30\> n9 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (clock_count\<30\> n7 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (mem_data\<30\> n5 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n110 n111 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n14 n122 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (ALU_data\<29\> n9 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (clock_count\<29\> n7 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (mem_data\<29\> n5 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n123 n124 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n19 n128 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (ALU_data\<28\> n9 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (clock_count\<28\> n7 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (mem_data\<28\> n5 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n129 n130 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n19 n134 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (ALU_data\<27\> n9 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (clock_count\<27\> n7 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (mem_data\<27\> n5 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n135 n136 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n140 n14 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (ALU_data\<26\> n9 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (clock_count\<26\> n7 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (mem_data\<26\> n5 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n141 n142 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n146 n19 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (ALU_data\<25\> n9 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (clock_count\<25\> n7 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (mem_data\<25\> n5 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (n147 n148 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n152 n19 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (ALU_data\<24\> n9 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (clock_count\<24\> n7 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (mem_data\<24\> n5 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n153 n154 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n14 n158 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (ALU_data\<23\> n9 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (clock_count\<23\> n7 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (mem_data\<23\> n5 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n159 n160 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n2 n164 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (ALU_data\<22\> n9 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (clock_count\<22\> n7 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (mem_data\<22\> n5 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n165 n166 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n14 n170 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (ALU_data\<21\> n9 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (clock_count\<21\> n7 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (mem_data\<21\> n5 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n171 n172 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n101 n176 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (ALU_data\<20\> n9 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (clock_count\<20\> n7 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (mem_data\<20\> n5 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n177 n178 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n189 n2 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (ALU_data\<19\> n9 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (clock_count\<19\> n7 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (mem_data\<19\> n5 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n190 n191 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (mem_load_width\<0\> mem_data\<15\> n210 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U202 (n212 n11 n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (n278 n253 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (mem_data\<7\> n11 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (n14 n207 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (ALU_data\<16\> n9 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (clock_count\<16\> n7 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U206 (mem_data\<16\> n5 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U205 (n213 n214 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n2 n195 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (ALU_data\<18\> n9 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n19 n201 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (ALU_data\<17\> n9 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (PC_incr\<0\> n17 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (clock_count\<0\> n7 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U258 (n260 n261 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U256 (ALU_data\<0\> n9 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (mem_data\<0\> n11 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U253 (n258 n259 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (clock_count\<17\> n7 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (mem_data\<17\> n5 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (mem_data\<18\> n5 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n196 n197 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (clock_count\<18\> n7 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n202 n203 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n220 n276 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (n13 mem_data\<15\> n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (ALU_data\<15\> n9 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (clock_count\<15\> n7 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n218 n219 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n226 n276 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (mem_data\<14\> n13 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (ALU_data\<14\> n9 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (clock_count\<14\> n7 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n224 n225 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n232 n276 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (mem_data\<13\> n13 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (ALU_data\<13\> n9 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (clock_count\<13\> n7 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n230 n231 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n238 n276 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U232 (mem_data\<12\> n13 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U230 (ALU_data\<12\> n9 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (clock_count\<12\> n7 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n236 n237 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n244 n276 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U238 (mem_data\<11\> n13 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (ALU_data\<11\> n9 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U235 (clock_count\<11\> n7 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n242 n243 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (clock_count\<10\> n7 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n252 n276 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n13 mem_data\<10\> n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (n273 n250 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (ALU_data\<10\> n9 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U241 (PC_incr\<10\> n17 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n248 n249 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (clock_count\<9\> n7 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n52 n276 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (mem_data\<9\> n13 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n275 n49 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n13 mem_data\<8\> n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n61 n276 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (clock_count\<8\> n7 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n274 n59 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (ALU_data\<8\> n9 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (PC_incr\<8\> n17 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n57 n58 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (ALU_data\<9\> n9 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (PC_incr\<9\> n17 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n45 n46 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n65 n66 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (ALU_data\<7\> n9 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (PC_incr\<7\> n17 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (clock_count\<7\> n7 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n67 n68 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (PC_incr\<6\> n17 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (clock_count\<6\> n7 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n75 n76 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (ALU_data\<6\> n9 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (mem_data\<6\> n11 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n72 n73 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (PC_incr\<5\> n17 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (clock_count\<5\> n7 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n82 n83 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (ALU_data\<5\> n9 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (mem_data\<5\> n11 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n80 n81 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (PC_incr\<4\> n17 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (clock_count\<4\> n7 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (n89 n90 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (ALU_data\<4\> n9 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (mem_data\<4\> n11 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n87 n88 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (PC_incr\<3\> n17 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (clock_count\<3\> n7 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n96 n97 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (ALU_data\<3\> n9 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (mem_data\<3\> n11 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n94 n95 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (PC_incr\<1\> n17 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (clock_count\<1\> n7 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n184 n185 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (PC_incr\<2\> n17 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n117 n118 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (clock_count\<2\> n7 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (ALU_data\<1\> n9 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (mem_data\<1\> n11 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n182 n183 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (ALU_data\<2\> n9 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (mem_data\<2\> n11 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n115 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n100 n99 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n108 n107 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (n121 n120 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U118 (n127 n126 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U124 (n133 n132 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U130 (n139 n138 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U136 (n144 n145 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U142 (n150 n151 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n157 n156 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U154 (n163 n162 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U160 (n169 n168 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U166 (n175 n174 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U179 (n187 n188 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U200 (n209 n1 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U203 (n10 mem_load_unsigned n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U201 (n211 n210 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U248 (n66 n254 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U197 (n206 n205 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (wb_src\<0\> n272 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U260 (n277 n272 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U255 (wb_src\<1\> n277 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U257 (wb_src\<0\> wb_src\<1\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U185 (n194 n193 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U247 (n253 n3 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U207 (n279 n3 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U250 (n10 mem_load_width\<0\> n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U252 (n256 n257 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U191 (n200 n199 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U209 (n216 n217 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U215 (n222 n223 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U221 (n228 n229 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U227 (n234 n235 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U233 (n240 n241 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U239 (n247 n246 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U43 (n44 n43 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U51 (n56 n55 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U59 (n63 n64 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (n70 n71 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n78 n79 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U79 (n85 n86 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U86 (n92 n93 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U172 (n180 n181 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (n113 n114 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U272 (n98 wb_data\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U271 (n106 wb_data\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U270 (n119 wb_data\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U269 (n125 wb_data\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U268 (n131 wb_data\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U267 (n137 wb_data\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U266 (n143 wb_data\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U265 (n149 wb_data\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U264 (n155 wb_data\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U263 (n161 wb_data\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U42 (n167 wb_data\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U41 (n173 wb_data\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U40 (n186 wb_data\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U2 (n276 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U277 (n208 n276 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U279 (mem_load_unsigned n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U37 (n204 wb_data\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n47 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n50 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n6 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n74 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n15 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n48 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n8 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n192 wb_data\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n53 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n12 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n105 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n4 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U273 (wb_src\<1\> n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U278 (wb_src\<0\> n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n18 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n101 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n18 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U280 (mem_load_width\<1\> n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U11 (n279 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n11 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n255 wb_data\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U38 (n198 wb_data\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U36 (n215 wb_data\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n221 wb_data\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U34 (n227 wb_data\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U33 (n233 wb_data\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (n239 wb_data\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n245 wb_data\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U274 (n251 n273 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n42 wb_data\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U276 (n51 n275 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U275 (n60 n274 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n54 wb_data\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U28 (n62 wb_data\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n69 wb_data\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (n77 wb_data\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n84 wb_data\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U24 (n91 wb_data\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n179 wb_data\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U23 (n112 wb_data\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
ends soc_no_opt_16may_write_back_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: MEMWB_preg
// View name: schematic
subckt soc_no_opt_16may_MEMWB_preg_schematic clk flush \
        mem_read_data_in\<31\> mem_read_data_in\<30\> \
        mem_read_data_in\<29\> mem_read_data_in\<28\> \
        mem_read_data_in\<27\> mem_read_data_in\<26\> \
        mem_read_data_in\<25\> mem_read_data_in\<24\> \
        mem_read_data_in\<23\> mem_read_data_in\<22\> \
        mem_read_data_in\<21\> mem_read_data_in\<20\> \
        mem_read_data_in\<19\> mem_read_data_in\<18\> \
        mem_read_data_in\<17\> mem_read_data_in\<16\> \
        mem_read_data_in\<15\> mem_read_data_in\<14\> \
        mem_read_data_in\<13\> mem_read_data_in\<12\> \
        mem_read_data_in\<11\> mem_read_data_in\<10\> \
        mem_read_data_in\<9\> mem_read_data_in\<8\> mem_read_data_in\<7\> \
        mem_read_data_in\<6\> mem_read_data_in\<5\> mem_read_data_in\<4\> \
        mem_read_data_in\<3\> mem_read_data_in\<2\> mem_read_data_in\<1\> \
        mem_read_data_in\<0\> mem_read_data_out\<31\> \
        mem_read_data_out\<30\> mem_read_data_out\<29\> \
        mem_read_data_out\<28\> mem_read_data_out\<27\> \
        mem_read_data_out\<26\> mem_read_data_out\<25\> \
        mem_read_data_out\<24\> mem_read_data_out\<23\> \
        mem_read_data_out\<22\> mem_read_data_out\<21\> \
        mem_read_data_out\<20\> mem_read_data_out\<19\> \
        mem_read_data_out\<18\> mem_read_data_out\<17\> \
        mem_read_data_out\<16\> mem_read_data_out\<15\> \
        mem_read_data_out\<14\> mem_read_data_out\<13\> \
        mem_read_data_out\<12\> mem_read_data_out\<11\> \
        mem_read_data_out\<10\> mem_read_data_out\<9\> \
        mem_read_data_out\<8\> mem_read_data_out\<7\> \
        mem_read_data_out\<6\> mem_read_data_out\<5\> \
        mem_read_data_out\<4\> mem_read_data_out\<3\> \
        mem_read_data_out\<2\> mem_read_data_out\<1\> \
        mem_read_data_out\<0\> ALU_data_in\<31\> ALU_data_in\<30\> \
        ALU_data_in\<29\> ALU_data_in\<28\> ALU_data_in\<27\> \
        ALU_data_in\<26\> ALU_data_in\<25\> ALU_data_in\<24\> \
        ALU_data_in\<23\> ALU_data_in\<22\> ALU_data_in\<21\> \
        ALU_data_in\<20\> ALU_data_in\<19\> ALU_data_in\<18\> \
        ALU_data_in\<17\> ALU_data_in\<16\> ALU_data_in\<15\> \
        ALU_data_in\<14\> ALU_data_in\<13\> ALU_data_in\<12\> \
        ALU_data_in\<11\> ALU_data_in\<10\> ALU_data_in\<9\> \
        ALU_data_in\<8\> ALU_data_in\<7\> ALU_data_in\<6\> \
        ALU_data_in\<5\> ALU_data_in\<4\> ALU_data_in\<3\> \
        ALU_data_in\<2\> ALU_data_in\<1\> ALU_data_in\<0\> \
        ALU_data_out\<31\> ALU_data_out\<30\> ALU_data_out\<29\> \
        ALU_data_out\<28\> ALU_data_out\<27\> ALU_data_out\<26\> \
        ALU_data_out\<25\> ALU_data_out\<24\> ALU_data_out\<23\> \
        ALU_data_out\<22\> ALU_data_out\<21\> ALU_data_out\<20\> \
        ALU_data_out\<19\> ALU_data_out\<18\> ALU_data_out\<17\> \
        ALU_data_out\<16\> ALU_data_out\<15\> ALU_data_out\<14\> \
        ALU_data_out\<13\> ALU_data_out\<12\> ALU_data_out\<11\> \
        ALU_data_out\<10\> ALU_data_out\<9\> ALU_data_out\<8\> \
        ALU_data_out\<7\> ALU_data_out\<6\> ALU_data_out\<5\> \
        ALU_data_out\<4\> ALU_data_out\<3\> ALU_data_out\<2\> \
        ALU_data_out\<1\> ALU_data_out\<0\> wb_src_in\<1\> wb_src_in\<0\> \
        wb_src_out\<1\> wb_src_out\<0\> wb_we_in wb_we_out rd_in\<4\> \
        rd_in\<3\> rd_in\<2\> rd_in\<1\> rd_in\<0\> rd_out\<4\> \
        rd_out\<3\> rd_out\<2\> rd_out\<1\> rd_out\<0\> \
        mem_load_width_in\<1\> mem_load_width_in\<0\> \
        mem_load_width_out\<1\> mem_load_width_out\<0\> \
        mem_load_unsigned_in mem_load_unsigned_out PC_incr_in\<10\> \
        PC_incr_in\<9\> PC_incr_in\<8\> PC_incr_in\<7\> PC_incr_in\<6\> \
        PC_incr_in\<5\> PC_incr_in\<4\> PC_incr_in\<3\> PC_incr_in\<2\> \
        PC_incr_in\<1\> PC_incr_in\<0\> PC_incr_out\<10\> PC_incr_out\<9\> \
        PC_incr_out\<8\> PC_incr_out\<7\> PC_incr_out\<6\> \
        PC_incr_out\<5\> PC_incr_out\<4\> PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> inh_gnd \
        inh_gnds inh_vdd inh_vdds
    Thru31 (mem_read_data_in\<0\> mem_read_data_out\<0\>) iprobe
    Thru30 (mem_read_data_in\<1\> mem_read_data_out\<1\>) iprobe
    Thru29 (mem_read_data_in\<2\> mem_read_data_out\<2\>) iprobe
    Thru28 (mem_read_data_in\<3\> mem_read_data_out\<3\>) iprobe
    Thru27 (mem_read_data_in\<4\> mem_read_data_out\<4\>) iprobe
    Thru26 (mem_read_data_in\<5\> mem_read_data_out\<5\>) iprobe
    Thru25 (mem_read_data_in\<6\> mem_read_data_out\<6\>) iprobe
    Thru24 (mem_read_data_in\<7\> mem_read_data_out\<7\>) iprobe
    Thru23 (mem_read_data_in\<8\> mem_read_data_out\<8\>) iprobe
    Thru22 (mem_read_data_in\<9\> mem_read_data_out\<9\>) iprobe
    Thru21 (mem_read_data_in\<10\> mem_read_data_out\<10\>) iprobe
    Thru20 (mem_read_data_in\<11\> mem_read_data_out\<11\>) iprobe
    Thru19 (mem_read_data_in\<12\> mem_read_data_out\<12\>) iprobe
    Thru18 (mem_read_data_in\<13\> mem_read_data_out\<13\>) iprobe
    Thru17 (mem_read_data_in\<14\> mem_read_data_out\<14\>) iprobe
    Thru16 (mem_read_data_in\<15\> mem_read_data_out\<15\>) iprobe
    Thru15 (mem_read_data_in\<16\> mem_read_data_out\<16\>) iprobe
    Thru14 (mem_read_data_in\<17\> mem_read_data_out\<17\>) iprobe
    Thru13 (mem_read_data_in\<18\> mem_read_data_out\<18\>) iprobe
    Thru12 (mem_read_data_in\<19\> mem_read_data_out\<19\>) iprobe
    Thru11 (mem_read_data_in\<20\> mem_read_data_out\<20\>) iprobe
    Thru10 (mem_read_data_in\<21\> mem_read_data_out\<21\>) iprobe
    Thru9 (mem_read_data_in\<22\> mem_read_data_out\<22\>) iprobe
    Thru8 (mem_read_data_in\<23\> mem_read_data_out\<23\>) iprobe
    Thru7 (mem_read_data_in\<24\> mem_read_data_out\<24\>) iprobe
    Thru6 (mem_read_data_in\<25\> mem_read_data_out\<25\>) iprobe
    Thru5 (mem_read_data_in\<26\> mem_read_data_out\<26\>) iprobe
    Thru4 (mem_read_data_in\<27\> mem_read_data_out\<27\>) iprobe
    Thru3 (mem_read_data_in\<28\> mem_read_data_out\<28\>) iprobe
    Thru2 (mem_read_data_in\<29\> mem_read_data_out\<29\>) iprobe
    Thru1 (mem_read_data_in\<30\> mem_read_data_out\<30\>) iprobe
    Thru0 (mem_read_data_in\<31\> mem_read_data_out\<31\>) iprobe
    mem_load_width_out_reg_0_ (clk n107 NeTt_429 n100 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_load_width_out_reg_1_ (clk n99 mem_load_width_out\<1\> NeTt_430 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_src_out_reg_1_ (clk wb_src_in\<1\> NeTt_431 n82 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_src_out_reg_0_ (clk wb_src_in\<0\> NeTt_432 n93 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_we_out_reg (clk N3 NeTt_433 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    mem_load_unsigned_out_reg (clk n86 NeTt_434 n102 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_3_ (clk n47 NeTt_435 n114 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_0_ (clk n44 NeTt_436 n112 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_4_ (clk n92 NeTt_437 n110 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_1_ (clk n81 NeTt_438 n104 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_2_ (clk n53 NeTt_439 n108 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_0_ (clk n74 PC_incr_out\<0\> NeTt_440 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_30_ (clk n106 ALU_data_out\<30\> NeTt_441 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_14_ (clk n98 ALU_data_out\<14\> NeTt_442 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_16_ (clk n97 ALU_data_out\<16\> NeTt_443 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_25_ (clk n96 ALU_data_out\<25\> NeTt_444 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_29_ (clk n95 ALU_data_out\<29\> NeTt_445 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_2_ (clk n91 ALU_data_out\<2\> NeTt_446 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_13_ (clk n90 ALU_data_out\<13\> NeTt_447 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_15_ (clk n89 ALU_data_out\<15\> NeTt_448 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_27_ (clk n88 ALU_data_out\<27\> NeTt_449 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_28_ (clk n87 ALU_data_out\<28\> NeTt_450 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_5_ (clk n85 PC_incr_out\<5\> NeTt_451 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_4_ (clk n84 PC_incr_out\<4\> NeTt_452 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_4_ (clk n80 ALU_data_out\<4\> NeTt_453 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_21_ (clk n79 ALU_data_out\<21\> NeTt_454 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_24_ (clk n78 ALU_data_out\<24\> NeTt_455 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_26_ (clk n77 ALU_data_out\<26\> NeTt_456 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_17_ (clk n76 ALU_data_out\<17\> NeTt_457 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_31_ (clk n75 ALU_data_out\<31\> NeTt_458 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_1_ (clk n73 PC_incr_out\<1\> NeTt_459 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_7_ (clk n72 PC_incr_out\<7\> NeTt_460 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_8_ (clk n71 PC_incr_out\<8\> NeTt_461 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_6_ (clk n70 PC_incr_out\<6\> NeTt_462 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_9_ (clk n69 ALU_data_out\<9\> NeTt_463 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_10_ (clk n68 ALU_data_out\<10\> NeTt_464 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_3_ (clk n67 ALU_data_out\<3\> NeTt_465 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_5_ (clk n66 ALU_data_out\<5\> NeTt_466 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_1_ (clk n65 ALU_data_out\<1\> NeTt_467 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_3_ (clk n64 PC_incr_out\<3\> NeTt_468 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_20_ (clk n63 ALU_data_out\<20\> NeTt_469 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_10_ (clk n62 PC_incr_out\<10\> NeTt_470 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_7_ (clk n61 ALU_data_out\<7\> NeTt_471 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_0_ (clk n60 ALU_data_out\<0\> NeTt_472 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_2_ (clk n59 PC_incr_out\<2\> NeTt_473 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_9_ (clk n55 PC_incr_out\<9\> NeTt_474 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_11_ (clk n58 ALU_data_out\<11\> NeTt_475 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_18_ (clk n57 ALU_data_out\<18\> NeTt_476 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_23_ (clk n56 ALU_data_out\<23\> NeTt_477 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_8_ (clk n54 ALU_data_out\<8\> NeTt_478 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_22_ (clk n52 ALU_data_out\<22\> NeTt_479 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_19_ (clk n51 ALU_data_out\<19\> NeTt_480 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_6_ (clk n48 ALU_data_out\<6\> NeTt_481 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_data_out_reg_12_ (clk n46 ALU_data_out\<12\> NeTt_482 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U60 (mem_load_width_in\<0\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U55 (mem_load_width_in\<1\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U43 (mem_load_unsigned_in n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U6 (rd_in\<3\> n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U3 (rd_in\<0\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U49 (rd_in\<4\> n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U39 (rd_in\<1\> n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U11 (rd_in\<2\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U32 (PC_incr_in\<0\> n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U59 (ALU_data_in\<30\> n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U54 (ALU_data_in\<14\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U53 (ALU_data_in\<16\> n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U52 (ALU_data_in\<25\> n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U51 (ALU_data_in\<29\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U48 (ALU_data_in\<2\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U47 (ALU_data_in\<13\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U46 (ALU_data_in\<15\> n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U45 (ALU_data_in\<27\> n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U44 (ALU_data_in\<28\> n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U42 (PC_incr_in\<5\> n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U41 (PC_incr_in\<4\> n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U38 (ALU_data_in\<4\> n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U37 (ALU_data_in\<21\> n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U36 (ALU_data_in\<24\> n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U35 (ALU_data_in\<26\> n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U34 (ALU_data_in\<17\> n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U33 (ALU_data_in\<31\> n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U31 (PC_incr_in\<1\> n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U30 (PC_incr_in\<7\> n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U29 (PC_incr_in\<8\> n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U28 (PC_incr_in\<6\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U27 (ALU_data_in\<9\> n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U26 (ALU_data_in\<10\> n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U25 (ALU_data_in\<3\> n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U24 (ALU_data_in\<5\> n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U23 (ALU_data_in\<1\> n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U22 (PC_incr_in\<3\> n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U21 (ALU_data_in\<20\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U20 (PC_incr_in\<10\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U19 (ALU_data_in\<7\> n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U18 (ALU_data_in\<0\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U17 (PC_incr_in\<2\> n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U13 (PC_incr_in\<9\> n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U16 (ALU_data_in\<11\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U15 (ALU_data_in\<18\> n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U14 (ALU_data_in\<23\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U12 (ALU_data_in\<8\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U10 (ALU_data_in\<22\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (ALU_data_in\<19\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U7 (ALU_data_in\<6\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U5 (ALU_data_in\<12\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U56 (n100 mem_load_width_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U50 (n93 wb_src_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U40 (n82 wb_src_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U65 (wb_we_in n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (n49 wb_we_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U57 (n102 mem_load_unsigned_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U64 (n114 rd_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U63 (n112 rd_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U62 (n110 rd_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U58 (n104 rd_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U61 (n108 rd_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n116 flush N3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_MEMWB_preg_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: clock_counter_DW01_inc_0
// View name: schematic
subckt soc_no_opt_16may_clock_counter_DW01_inc_0_schematic A\<63\> A\<62\> \
        A\<61\> A\<60\> A\<59\> A\<58\> A\<57\> A\<56\> A\<55\> A\<54\> \
        A\<53\> A\<52\> A\<51\> A\<50\> A\<49\> A\<48\> A\<47\> A\<46\> \
        A\<45\> A\<44\> A\<43\> A\<42\> A\<41\> A\<40\> A\<39\> A\<38\> \
        A\<37\> A\<36\> A\<35\> A\<34\> A\<33\> A\<32\> A\<31\> A\<30\> \
        A\<29\> A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> \
        A\<21\> A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> \
        A\<13\> A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> \
        A\<4\> A\<3\> A\<2\> A\<1\> A\<0\> SUM\<63\> SUM\<62\> SUM\<61\> \
        SUM\<60\> SUM\<59\> SUM\<58\> SUM\<57\> SUM\<56\> SUM\<55\> \
        SUM\<54\> SUM\<53\> SUM\<52\> SUM\<51\> SUM\<50\> SUM\<49\> \
        SUM\<48\> SUM\<47\> SUM\<46\> SUM\<45\> SUM\<44\> SUM\<43\> \
        SUM\<42\> SUM\<41\> SUM\<40\> SUM\<39\> SUM\<38\> SUM\<37\> \
        SUM\<36\> SUM\<35\> SUM\<34\> SUM\<33\> SUM\<32\> SUM\<31\> \
        SUM\<30\> SUM\<29\> SUM\<28\> SUM\<27\> SUM\<26\> SUM\<25\> \
        SUM\<24\> SUM\<23\> SUM\<22\> SUM\<21\> SUM\<20\> SUM\<19\> \
        SUM\<18\> SUM\<17\> SUM\<16\> SUM\<15\> SUM\<14\> SUM\<13\> \
        SUM\<12\> SUM\<11\> SUM\<10\> SUM\<9\> SUM\<8\> SUM\<7\> SUM\<6\> \
        SUM\<5\> SUM\<4\> SUM\<3\> SUM\<2\> SUM\<1\> SUM\<0\> inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U296 (n259 A\<2\> n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U396 (n222 n87 n334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U199 (n183 A\<4\> n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U130 (n128 A\<6\> n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (n136 n116 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U144 (n115 n34 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U156 (n114 n49 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U165 (n113 n15 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U174 (n112 n32 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U183 (n171 n111 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U241 (n105 n45 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U253 (n104 n11 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n103 n27 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U271 (n102 n43 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U398 (SUM\<0\> n86 n335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U192 (n178 n110 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U205 (n188 n109 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U214 (n195 n108 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U223 (n202 n107 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U232 (n106 n29 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U394 (n88 n51 n333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U123 (n122 A\<8\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U280 (n101 n9 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U289 (n100 n25 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U302 (n99 n41 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U311 (n98 n7 n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U320 (n97 n23 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U329 (n96 n39 n284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U338 (n95 n5 n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U350 (n94 n21 n300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U359 (n93 n37 n307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U368 (n315 n92 n314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U386 (n90 n2 n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U392 (n89 n17 n332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U389 (n330 A\<10\> n331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U380 (n324 A\<12\> n325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U371 (n317 A\<14\> n318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U362 (n310 A\<16\> n311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U353 (n303 A\<18\> n304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U377 (n91 n19 n321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U341 (n294 A\<20\> n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U332 (n287 A\<22\> n288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U323 (n280 A\<24\> n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U314 (n273 A\<26\> n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U305 (n266 A\<28\> n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U292 (n256 A\<30\> n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U283 (n249 A\<32\> n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U274 (n242 A\<34\> n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U265 (n235 A\<36\> n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U256 (n228 A\<38\> n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U244 (n218 A\<40\> n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U235 (n211 A\<42\> n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U226 (n204 A\<44\> n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U217 (n197 A\<46\> n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U208 (n190 A\<48\> n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U195 (n180 A\<50\> n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U186 (n173 A\<52\> n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U177 (n166 A\<54\> n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U168 (n159 A\<56\> n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U159 (n152 A\<58\> n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U147 (n142 A\<60\> n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U142 (n136 A\<61\> n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U134 (n131 A\<63\> n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U345 (n86 A\<0\> n296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U343 (n296 n297 SUM\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U344 (A\<1\> SUM\<0\> n297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U295 (n259 A\<2\> n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U294 (n53 n258 SUM\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U247 (n222 A\<3\> n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n220 n221 SUM\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U248 (n87 n35 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U395 (n334 A\<4\> n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n50 A\<5\> n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (n183 A\<4\> n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n84 n182 SUM\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n128 A\<6\> n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n83 n127 SUM\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n117 n133 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n134 n135 SUM\<62\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n52 A\<62\> n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n139 A\<60\> n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n115 n33 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n147 n148 SUM\<59\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (A\<59\> n34 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n149 A\<58\> n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n114 n48 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n154 n155 SUM\<57\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (A\<57\> n49 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n156 A\<56\> n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n113 n14 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n161 n162 SUM\<55\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (A\<55\> n15 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n163 A\<54\> n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n112 n31 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n168 n169 SUM\<53\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n32 A\<53\> n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n170 A\<52\> n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n111 n47 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n175 n176 SUM\<51\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (A\<51\> n171 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n110 n13 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (n185 n186 SUM\<49\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U202 (A\<49\> n178 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (n109 n30 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n192 n193 SUM\<47\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (A\<47\> n188 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (n108 n46 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n199 n200 SUM\<45\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (A\<45\> n195 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U230 (n107 n12 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n206 n207 SUM\<43\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (A\<43\> n202 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n106 n28 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n213 n214 SUM\<41\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U238 (A\<41\> n29 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n215 A\<40\> n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (n105 n44 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (n223 n224 SUM\<39\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U250 (A\<39\> n45 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (n225 A\<38\> n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n104 n10 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U258 (n230 n231 SUM\<37\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (A\<37\> n11 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (n232 A\<36\> n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n103 n26 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (n237 n238 SUM\<35\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n27 A\<35\> n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U270 (n239 A\<34\> n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U397 (n335 A\<2\> n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n177 A\<50\> n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (n187 A\<48\> n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n194 A\<46\> n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n201 A\<44\> n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n208 A\<42\> n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U297 (A\<1\> A\<0\> n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (A\<3\> n35 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (A\<62\> n133 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n33 A\<59\> n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n48 A\<57\> n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n14 A\<55\> n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n31 A\<53\> n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n47 A\<51\> n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n13 A\<49\> n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (n30 A\<47\> n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n46 A\<45\> n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n12 A\<43\> n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n28 A\<41\> n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n44 A\<39\> n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U257 (n10 A\<37\> n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U266 (n26 A\<35\> n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U393 (n333 A\<6\> n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n88 n50 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (A\<5\> n51 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n144 n145 SUM\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n122 A\<8\> n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n82 n121 SUM\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U278 (n102 n42 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n244 n245 SUM\<33\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (A\<33\> n43 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (n246 A\<32\> n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U287 (n101 n8 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U285 (n251 n252 SUM\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U286 (n9 A\<31\> n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U288 (n253 A\<30\> n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U300 (n100 n24 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U298 (n261 n262 SUM\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U299 (n25 A\<29\> n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U301 (n263 A\<28\> n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U309 (n99 n40 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U307 (n268 n269 SUM\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U308 (A\<27\> n41 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U310 (n270 A\<26\> n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U318 (n98 n6 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U316 (n275 n276 SUM\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U317 (A\<25\> n7 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U319 (n277 A\<24\> n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (n97 n22 n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (n282 n283 SUM\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U326 (A\<23\> n23 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U328 (n284 A\<22\> n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U336 (n96 n38 n289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U334 (n289 n290 SUM\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U335 (A\<21\> n39 n290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (n291 A\<20\> n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U348 (n95 n4 n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U346 (n298 n299 SUM\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U347 (A\<19\> n5 n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U349 (n300 A\<18\> n292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U357 (n94 n20 n305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U355 (n305 n306 SUM\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U356 (A\<17\> n21 n306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U358 (n307 A\<16\> n301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U366 (n93 n36 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U364 (n312 n313 SUM\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U365 (A\<15\> n37 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U367 (n314 A\<14\> n308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U375 (n92 n3 n319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U373 (n319 n320 SUM\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U374 (n315 A\<13\> n320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U384 (n91 n18 n326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U382 (n326 n327 SUM\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U383 (A\<11\> n19 n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U385 (n328 A\<10\> n322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n90 n1 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n118 n119 SUM\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (A\<9\> n2 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U391 (n332 A\<8\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n89 n16 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (A\<7\> n17 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n124 n125 SUM\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U388 (n330 A\<10\> n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U387 (n54 n329 SUM\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U379 (n324 A\<12\> n323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U378 (n55 n323 SUM\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U370 (n317 A\<14\> n316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U369 (n56 n316 SUM\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U361 (n310 A\<16\> n309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U360 (n57 n309 SUM\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U352 (n303 A\<18\> n302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U351 (n58 n302 SUM\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U376 (n321 A\<12\> n315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n16 A\<7\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (n42 A\<33\> n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U284 (n8 A\<31\> n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (n24 A\<29\> n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U306 (n40 A\<27\> n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U315 (n6 A\<25\> n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U324 (n22 A\<23\> n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (n38 A\<21\> n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U342 (n4 A\<19\> n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U354 (n20 A\<17\> n303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U363 (n36 A\<15\> n310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U372 (A\<13\> n3 n317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U381 (n18 A\<11\> n324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U390 (n1 A\<9\> n330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U340 (n294 A\<20\> n293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U339 (n59 n293 SUM\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U331 (n287 A\<22\> n286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U330 (n60 n286 SUM\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U322 (n280 A\<24\> n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U321 (n61 n279 SUM\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U313 (n273 A\<26\> n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U312 (n62 n272 SUM\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U304 (n266 A\<28\> n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U303 (n63 n265 SUM\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U291 (n256 A\<30\> n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U290 (n64 n255 SUM\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U282 (n249 A\<32\> n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (n65 n248 SUM\<32\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n242 A\<34\> n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n66 n241 SUM\<34\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n235 A\<36\> n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U263 (n67 n234 SUM\<36\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U255 (n228 A\<38\> n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n68 n227 SUM\<38\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (n218 A\<40\> n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (n69 n217 SUM\<40\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n211 A\<42\> n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (n70 n210 SUM\<42\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n204 A\<44\> n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (n71 n203 SUM\<44\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n197 A\<46\> n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n72 n196 SUM\<46\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n190 A\<48\> n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U206 (n73 n189 SUM\<48\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n180 A\<50\> n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n74 n179 SUM\<50\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n173 A\<52\> n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n75 n172 SUM\<52\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n166 A\<54\> n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n76 n165 SUM\<54\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n159 A\<56\> n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n77 n158 SUM\<56\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n152 A\<58\> n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n78 n151 SUM\<58\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n142 A\<60\> n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n79 n141 SUM\<60\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (A\<61\> n136 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n80 n137 SUM\<61\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n81 n130 SUM\<63\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (A\<63\> n131 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n260 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (n146 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U84 (n184 n84 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U83 (n129 n83 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U117 (A\<62\> n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U52 (n133 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U116 (A\<61\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U33 (n140 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (n150 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n157 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (n164 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n209 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n216 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n226 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n233 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (A\<1\> n86 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U85 (A\<0\> SUM\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U87 (A\<3\> n87 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (n222 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U115 (A\<59\> n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U34 (n33 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U114 (A\<57\> n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n48 n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U113 (A\<55\> n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n14 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U112 (A\<53\> n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (n31 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U111 (A\<51\> n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U47 (n171 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U110 (A\<49\> n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n178 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U109 (A\<47\> n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U30 (n188 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U108 (A\<45\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U46 (n195 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U107 (A\<43\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n202 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U106 (A\<41\> n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n28 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U105 (A\<39\> n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U45 (n44 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U104 (A\<37\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U11 (n10 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U103 (A\<35\> n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n26 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n126 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (n50 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (n123 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U102 (A\<33\> n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U43 (n42 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (n240 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n247 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n254 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n264 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n271 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (n278 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (n285 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n292 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n301 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n308 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n322 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n120 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n331 n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (n325 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (n318 n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (n311 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (n304 n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U88 (A\<5\> n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U101 (A\<31\> n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n8 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U100 (A\<29\> n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n24 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U99 (A\<27\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n40 n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U98 (A\<25\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n6 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U97 (A\<23\> n97 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (n22 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U96 (A\<21\> n96 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n38 n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U95 (A\<19\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n4 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U94 (A\<17\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n20 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U93 (A\<15\> n93 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n36 n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U92 (A\<13\> n92 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n315 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U91 (A\<11\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U90 (A\<9\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U89 (A\<7\> n89 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n295 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (n288 n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n281 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n274 n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (n267 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n257 n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n250 n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n243 n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n236 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U68 (n229 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n219 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (n212 n70 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (n205 n71 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U72 (n198 n72 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U73 (n191 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U74 (n181 n74 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (n174 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (n167 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n160 n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n153 n78 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U79 (n143 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U80 (n138 n80 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U81 (n132 n81 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
ends soc_no_opt_16may_clock_counter_DW01_inc_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: clock_counter
// View name: schematic
subckt soc_no_opt_16may_clock_counter_schematic clk cnt_en nreset \
        cnt\<63\> cnt\<62\> cnt\<61\> cnt\<60\> cnt\<59\> cnt\<58\> \
        cnt\<57\> cnt\<56\> cnt\<55\> cnt\<54\> cnt\<53\> cnt\<52\> \
        cnt\<51\> cnt\<50\> cnt\<49\> cnt\<48\> cnt\<47\> cnt\<46\> \
        cnt\<45\> cnt\<44\> cnt\<43\> cnt\<42\> cnt\<41\> cnt\<40\> \
        cnt\<39\> cnt\<38\> cnt\<37\> cnt\<36\> cnt\<35\> cnt\<34\> \
        cnt\<33\> cnt\<32\> cnt\<31\> cnt\<30\> cnt\<29\> cnt\<28\> \
        cnt\<27\> cnt\<26\> cnt\<25\> cnt\<24\> cnt\<23\> cnt\<22\> \
        cnt\<21\> cnt\<20\> cnt\<19\> cnt\<18\> cnt\<17\> cnt\<16\> \
        cnt\<15\> cnt\<14\> cnt\<13\> cnt\<12\> cnt\<11\> cnt\<10\> \
        cnt\<9\> cnt\<8\> cnt\<7\> cnt\<6\> cnt\<5\> cnt\<4\> cnt\<3\> \
        cnt\<2\> cnt\<1\> cnt\<0\> inh_gnd inh_gnds inh_vdd inh_vdds
    U201 (n259 n263 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U267 (cnt_en n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U266 (n133 n328 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U265 (nreset n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n6 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U263 (n226 cnt\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U262 (n228 cnt\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U261 (n220 cnt\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U260 (n222 cnt\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U259 (n224 cnt\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U258 (n216 cnt\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U257 (n218 cnt\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U256 (n210 cnt\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U255 (n212 cnt\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U254 (n214 cnt\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U253 (n206 cnt\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U252 (n200 cnt\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U251 (n202 cnt\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U250 (n204 cnt\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U249 (n198 cnt\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U248 (n208 cnt\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U247 (n227 cnt\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U246 (n229 cnt\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U245 (n221 cnt\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U244 (n223 cnt\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U243 (n215 cnt\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U242 (n217 cnt\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U241 (n219 cnt\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U240 (n211 cnt\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U239 (n213 cnt\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U238 (n205 cnt\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U237 (n207 cnt\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U236 (n209 cnt\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U264 (n328 n326 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n326 n260 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U235 (n201 cnt\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U200 (n3 cnt\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U234 (n203 cnt\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U233 (n199 cnt\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U232 (n261 cnt\<61\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U231 (n255 cnt\<62\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U230 (n257 cnt\<59\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U229 (n250 cnt\<57\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U228 (n252 cnt\<55\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U227 (n254 cnt\<53\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U226 (n246 cnt\<51\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U225 (n248 cnt\<49\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U224 (n240 cnt\<47\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U223 (n242 cnt\<45\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U222 (n244 cnt\<43\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U221 (n236 cnt\<41\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U220 (n238 cnt\<39\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U219 (n230 cnt\<37\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U218 (n232 cnt\<35\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U217 (n234 cnt\<33\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U216 (n256 cnt\<60\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U215 (n258 cnt\<58\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U214 (n251 cnt\<56\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U213 (n253 cnt\<54\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U212 (n245 cnt\<52\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U211 (n247 cnt\<50\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U210 (n249 cnt\<48\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U209 (n241 cnt\<46\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U208 (n243 cnt\<44\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U207 (n235 cnt\<42\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U206 (n237 cnt\<40\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U205 (n239 cnt\<38\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U204 (n231 cnt\<36\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U203 (n233 cnt\<34\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U202 (n225 cnt\<32\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    count_reg_63_ (clk n134 cnt\<63\> n259 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_31_ (clk n166 NeTt_809 n226 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_29_ (clk n168 NeTt_810 n228 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_27_ (clk n170 NeTt_811 n220 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_25_ (clk n172 NeTt_812 n222 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_23_ (clk n174 NeTt_813 n224 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_21_ (clk n176 NeTt_814 n216 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_19_ (clk n178 NeTt_815 n218 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_17_ (clk n180 NeTt_816 n210 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_15_ (clk n182 NeTt_817 n212 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_13_ (clk n184 NeTt_818 n214 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_11_ (clk n186 NeTt_819 n206 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_7_ (clk n190 NeTt_820 n200 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_5_ (clk n192 NeTt_821 n202 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_3_ (clk n194 NeTt_822 n204 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_1_ (clk n196 NeTt_823 n198 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_9_ (clk n188 NeTt_824 n208 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_30_ (clk n167 NeTt_825 n227 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_28_ (clk n169 NeTt_826 n229 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_26_ (clk n171 NeTt_827 n221 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_24_ (clk n173 NeTt_828 n223 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_22_ (clk n175 NeTt_829 n215 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_20_ (clk n177 NeTt_830 n217 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_18_ (clk n179 NeTt_831 n219 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_16_ (clk n181 NeTt_832 n211 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_14_ (clk n183 NeTt_833 n213 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_12_ (clk n185 NeTt_834 n205 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_10_ (clk n187 NeTt_835 n207 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_8_ (clk n189 NeTt_836 n209 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_6_ (clk n191 NeTt_837 n201 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_0_ (clk n197 NeTt_838 n3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    count_reg_4_ (clk n193 NeTt_839 n203 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_2_ (clk n195 NeTt_840 n199 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_61_ (clk n136 NeTt_841 n261 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_62_ (clk n135 NeTt_842 n255 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_59_ (clk n138 NeTt_843 n257 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_57_ (clk n140 NeTt_844 n250 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_55_ (clk n142 NeTt_845 n252 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_53_ (clk n144 NeTt_846 n254 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_51_ (clk n146 NeTt_847 n246 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_49_ (clk n148 NeTt_848 n248 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_47_ (clk n150 NeTt_849 n240 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_45_ (clk n152 NeTt_850 n242 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_43_ (clk n154 NeTt_851 n244 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_41_ (clk n156 NeTt_852 n236 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_39_ (clk n158 NeTt_853 n238 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_37_ (clk n160 NeTt_854 n230 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_35_ (clk n162 NeTt_855 n232 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_33_ (clk n164 NeTt_856 n234 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_60_ (clk n137 NeTt_857 n256 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_58_ (clk n139 NeTt_858 n258 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_56_ (clk n141 NeTt_859 n251 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_54_ (clk n143 NeTt_860 n253 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_52_ (clk n145 NeTt_861 n245 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_50_ (clk n147 NeTt_862 n247 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_48_ (clk n149 NeTt_863 n249 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_46_ (clk n151 NeTt_864 n241 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_44_ (clk n153 NeTt_865 n243 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_42_ (clk n155 NeTt_866 n235 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_40_ (clk n157 NeTt_867 n237 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_38_ (clk n159 NeTt_868 n239 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_36_ (clk n161 NeTt_869 n231 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_34_ (clk n163 NeTt_870 n233 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    count_reg_32_ (clk n165 NeTt_871 n225 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U8 (n263 n328 n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7 (N67 n2 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U6 (n4 n5 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U199 (nreset n329 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (cnt\<31\> n328 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (N35 n2 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n69 n70 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (cnt\<29\> n328 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (N33 n2 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n73 n74 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n328 cnt\<27\> n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (N31 n2 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n77 n78 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (cnt\<25\> n328 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (N29 n2 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n81 n82 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (cnt\<23\> n328 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (N27 n2 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n85 n86 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (cnt\<21\> n260 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (N25 n2 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n89 n90 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (cnt\<19\> n328 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (N23 n2 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n93 n94 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (cnt\<17\> n328 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (N21 n2 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n97 n98 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (cnt\<15\> n260 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (N19 n2 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n101 n102 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (cnt\<13\> n260 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (N17 n2 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n105 n106 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (cnt\<11\> n260 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (N15 n2 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n109 n110 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (cnt\<7\> n260 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (N11 n2 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (n117 n118 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (cnt\<5\> n328 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (N9 n2 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n121 n122 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (cnt\<3\> n328 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (N7 n2 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n125 n126 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (cnt\<1\> n260 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (N5 n2 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n129 n130 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (cnt\<9\> n328 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (N13 n2 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (n113 n114 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (cnt\<30\> n260 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (N34 n2 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n71 n72 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (cnt\<28\> n328 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (N32 n2 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n75 n76 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (cnt\<26\> n260 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (N30 n2 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n79 n80 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (cnt\<24\> n260 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (N28 n2 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n83 n84 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (cnt\<22\> n260 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (N26 n2 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n87 n88 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (cnt\<20\> n260 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (N24 n2 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n91 n92 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (cnt\<18\> n260 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (N22 n2 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n95 n96 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (cnt\<16\> n260 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (N20 n2 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n99 n100 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (cnt\<14\> n328 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (N18 n2 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (n103 n104 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (cnt\<12\> n328 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (N16 n2 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n107 n108 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (cnt\<10\> n260 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (N14 n2 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n111 n112 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (cnt\<8\> n260 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (N12 n2 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n115 n116 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (cnt\<0\> n260 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (N4 n2 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (n131 n132 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (cnt\<4\> n260 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (N8 n2 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (n123 n124 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (cnt\<2\> n260 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (N6 n2 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (n127 n128 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U14 (cnt\<61\> n260 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U13 (N65 n2 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U12 (n9 n10 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (cnt\<62\> n328 n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (N66 n2 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U9 (n7 n8 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U20 (cnt\<59\> n260 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (N63 n2 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (n13 n14 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (cnt\<57\> n328 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (N61 n2 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (n17 n18 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (cnt\<55\> n328 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (N59 n2 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (n21 n22 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (cnt\<53\> n328 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (N57 n2 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n25 n26 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (cnt\<51\> n260 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (N55 n2 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n29 n30 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (cnt\<49\> n260 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (N53 n2 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n33 n34 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (cnt\<47\> n328 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (N51 n2 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n37 n38 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (cnt\<45\> n328 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (N49 n2 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n41 n42 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (cnt\<43\> n328 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (N47 n2 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n45 n46 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (cnt\<41\> n260 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (N45 n2 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n49 n50 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (cnt\<39\> n260 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (N43 n2 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (n53 n54 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (cnt\<37\> n328 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (N41 n2 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n57 n58 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (cnt\<35\> n260 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (N39 n2 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n61 n62 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (cnt\<33\> n260 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (N37 n2 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n65 n66 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (cnt\<60\> n328 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (N64 n2 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U15 (n11 n12 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (cnt\<58\> n260 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (N62 n2 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U21 (n15 n16 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (cnt\<56\> n328 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (N60 n2 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n19 n20 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (cnt\<54\> n328 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (N58 n2 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n23 n24 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (cnt\<52\> n328 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (N56 n2 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (n27 n28 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (cnt\<50\> n260 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (N54 n2 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n31 n32 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (cnt\<48\> n260 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (N52 n2 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n35 n36 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (cnt\<46\> n260 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (N50 n2 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n39 n40 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (cnt\<44\> n328 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (N48 n2 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n43 n44 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (cnt\<42\> n328 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (N46 n2 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n47 n48 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (cnt\<40\> n260 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (N44 n2 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n51 n52 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (cnt\<38\> n260 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (N42 n2 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n55 n56 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (cnt\<32\> n260 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (cnt\<36\> n328 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (N40 n2 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n59 n60 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (cnt\<34\> n328 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (N38 n2 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n63 n64 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (cnt\<6\> n328 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n119 n120 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (N10 n2 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (N36 n2 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n67 n68 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    add_28 (n263 cnt\<62\> cnt\<61\> cnt\<60\> cnt\<59\> cnt\<58\> \
        cnt\<57\> cnt\<56\> cnt\<55\> cnt\<54\> cnt\<53\> cnt\<52\> \
        cnt\<51\> cnt\<50\> cnt\<49\> cnt\<48\> cnt\<47\> cnt\<46\> \
        cnt\<45\> cnt\<44\> cnt\<43\> cnt\<42\> cnt\<41\> cnt\<40\> \
        cnt\<39\> cnt\<38\> cnt\<37\> cnt\<36\> cnt\<35\> cnt\<34\> \
        cnt\<33\> cnt\<32\> cnt\<31\> cnt\<30\> cnt\<29\> cnt\<28\> \
        cnt\<27\> cnt\<26\> cnt\<25\> cnt\<24\> cnt\<23\> cnt\<22\> \
        cnt\<21\> cnt\<20\> cnt\<19\> cnt\<18\> cnt\<17\> cnt\<16\> \
        cnt\<15\> cnt\<14\> cnt\<13\> cnt\<12\> cnt\<11\> cnt\<10\> \
        cnt\<9\> cnt\<8\> cnt\<7\> cnt\<6\> cnt\<5\> cnt\<4\> cnt\<3\> \
        cnt\<2\> cnt\<1\> cnt\<0\> N67 N66 N65 N64 N63 N62 N61 N60 N59 N58 \
        N57 N56 N55 N54 N53 N52 N51 N50 N49 N48 N47 N46 N45 N44 N43 N42 \
        N41 N40 N39 N38 N37 N36 N35 N34 N33 N32 N31 N30 N29 N28 N27 N26 \
        N25 N24 N23 N22 N21 N20 N19 N18 N17 N16 N15 N14 N13 N12 N11 N10 N9 \
        N8 N7 N6 N5 N4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_clock_counter_DW01_inc_0_schematic
    U197 (n328 n327 n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_clock_counter_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: register_file
// View name: schematic
subckt soc_no_opt_16may_register_file_schematic clk nreset reg_write \
        read_register_1\<4\> read_register_1\<3\> read_register_1\<2\> \
        read_register_1\<1\> read_register_1\<0\> read_register_2\<4\> \
        read_register_2\<3\> read_register_2\<2\> read_register_2\<1\> \
        read_register_2\<0\> write_register\<4\> write_register\<3\> \
        write_register\<2\> write_register\<1\> write_register\<0\> \
        write_data\<31\> write_data\<30\> write_data\<29\> \
        write_data\<28\> write_data\<27\> write_data\<26\> \
        write_data\<25\> write_data\<24\> write_data\<23\> \
        write_data\<22\> write_data\<21\> write_data\<20\> \
        write_data\<19\> write_data\<18\> write_data\<17\> \
        write_data\<16\> write_data\<15\> write_data\<14\> \
        write_data\<13\> write_data\<12\> write_data\<11\> \
        write_data\<10\> write_data\<9\> write_data\<8\> write_data\<7\> \
        write_data\<6\> write_data\<5\> write_data\<4\> write_data\<3\> \
        write_data\<2\> write_data\<1\> write_data\<0\> read_data_1\<31\> \
        read_data_1\<30\> read_data_1\<29\> read_data_1\<28\> \
        read_data_1\<27\> read_data_1\<26\> read_data_1\<25\> \
        read_data_1\<24\> read_data_1\<23\> read_data_1\<22\> \
        read_data_1\<21\> read_data_1\<20\> read_data_1\<19\> \
        read_data_1\<18\> read_data_1\<17\> read_data_1\<16\> \
        read_data_1\<15\> read_data_1\<14\> read_data_1\<13\> \
        read_data_1\<12\> read_data_1\<11\> read_data_1\<10\> \
        read_data_1\<9\> read_data_1\<8\> read_data_1\<7\> \
        read_data_1\<6\> read_data_1\<5\> read_data_1\<4\> \
        read_data_1\<3\> read_data_1\<2\> read_data_1\<1\> \
        read_data_1\<0\> read_data_2\<31\> read_data_2\<30\> \
        read_data_2\<29\> read_data_2\<28\> read_data_2\<27\> \
        read_data_2\<26\> read_data_2\<25\> read_data_2\<24\> \
        read_data_2\<23\> read_data_2\<22\> read_data_2\<21\> \
        read_data_2\<20\> read_data_2\<19\> read_data_2\<18\> \
        read_data_2\<17\> read_data_2\<16\> read_data_2\<15\> \
        read_data_2\<14\> read_data_2\<13\> read_data_2\<12\> \
        read_data_2\<11\> read_data_2\<10\> read_data_2\<9\> \
        read_data_2\<8\> read_data_2\<7\> read_data_2\<6\> \
        read_data_2\<5\> read_data_2\<4\> read_data_2\<3\> \
        read_data_2\<2\> read_data_2\<1\> read_data_2\<0\> inh_gnd \
        inh_gnds inh_vdd_rename inh_vdds
    Vregister_file (inh_vdd_rename inh_vdd) vsource dc=0 type=dc 
    U9238 (n10161 n10160 n10162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9231 (n10155 n10154 n10163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9221 (n7480 n10144 n10145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9220 (n10144 write_register\<1\> n10146 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U9222 (n10146 n10145 n10147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9216 (n10140 n10139 n10141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9209 (n10134 n10133 n10142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4301 (n4274 N230 n4273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9199 (n10123 n41 n10124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9198 (n10123 write_register\<1\> n10125 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U9200 (n10125 n10124 n10126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2199 (n10205 N237 n2203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2107 (n10206 n9790 n2141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U520 (n580 n581 n579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U530 (n7789 n115 n591 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U531 (n8307 n103 n590 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U529 (n590 n591 n589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U527 (n7881 n66 n586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U526 (n8403 n97 n587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U525 (n586 n587 n582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U524 (n7819 n40 n584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U523 (n8369 n9359 n585 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U522 (n584 n585 n583 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7397 (n6374 n22 n4873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6853 (n6001 n22 n4470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6753 (n5934 write_register\<2\> n4402 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U2185 (n2198 n2196 n2197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9197 (n60 n7579 n10123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U9219 (n9791 n130 n10144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2201 (n2196 n2179 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7399 (n10122 write_data\<1\> n6375 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7395 (n6373 write_register\<4\> n4403 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7053 (n6135 write_register\<1\> n4604 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7381 (n7579 n6269 n4805 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7153 (n6202 write_register\<1\> n4671 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U6953 (n6068 n22 n4537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6901 (n6004 n9634 n6034 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6900 (n6033 n6034 n6487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6902 (n7577 n81 n6033 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7315 (n7482 write_data\<15\> n6316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7253 (n6269 write_register\<0\> n4738 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7392 (n9796 n131 n6370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7391 (n9428 n8235 n6371 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7390 (n6370 n6371 n6633 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6555 (reg_write n5800 n5403 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2195 (read_register_2\<1\> n10164 n2144 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U2149 (n7480 n9790 n2172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5867 (n5336 n11 n4872 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7383 (n10200 n11 n5867 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7384 (reg_write write_register\<4\> n6365 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U2178 (n7604 n9790 n2136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2194 (n9361 n9790 n2145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2190 (n9791 n2201 n2187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2114 (n10206 n38 n2133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2111 (n10202 n9791 n2131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2159 (n2179 n9791 n2171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1403 (n9327 n113 n1451 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2162 (n10164 n9790 n2180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2139 (n9790 n2162 n2153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2136 (read_register_2\<0\> n2162 n2152 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U2171 (n2188 n9790 n2132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1433 (n9161 n68 n1478 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1436 (n7963 n64 n1480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1423 (n7885 n66 n1468 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1404 (n9313 n111 n1450 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1427 (n204 n9069 n1472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1425 (n1472 n1473 n1471 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1426 (n9089 n115 n1473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1416 (n1462 n1463 n1461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1422 (n9105 n97 n1469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1421 (n1468 n1469 n1464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1420 (n7821 n40 n1466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1419 (n9097 n9359 n1467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1418 (n1466 n1467 n1465 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1383 (n1428 n1429 n1427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1385 (n1432 n1433 n1431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1429 (n1474 n1475 n1460 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1443 (n9145 n9360 n1486 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1442 (n9153 n105 n1487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1441 (n1486 n1487 n1482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1440 (n9127 n10203 n1484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1439 (n9137 n9017 n1485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1438 (n1484 n1485 n1483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1435 (n7997 n95 n1481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1434 (n1480 n1481 n1476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1432 (n9016 n7929 n1479 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1431 (n1478 n1479 n1477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1402 (n1450 n1451 n1449 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1400 (n1446 n1447 n1430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1414 (n9275 n109 n1458 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1413 (n9299 n117 n1459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1412 (n1458 n1459 n1454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1411 (n9237 n8263 n1456 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1410 (n9251 n48 n1457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1409 (n1456 n1457 n1455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1407 (n9341 n119 n1452 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1406 (n9355 n99 n1453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1405 (n1452 n1453 n1448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7389 (write_data\<0\> n10122 n6369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7388 (n7542 n131 n6367 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7387 (n8237 n4277 n6368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7386 (n6367 n6368 n6632 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6957 (n7542 n9891 n6069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6956 (n9784 n8893 n6070 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6955 (n6069 n6070 n6504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5575 (n7542 n9939 n5138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5574 (n9936 n8551 n5139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5573 (n5138 n5139 n7048 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4294 (n9990 n8551 n4269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4291 (n9761 n8597 n4270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4267 (n4251 n4252 n4233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4290 (n4269 n4270 n4262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4287 (n7601 n9129 n4264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4285 (n9999 n8497 n4265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4284 (n4264 n4265 n4263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4279 (n10005 n8713 n4259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4277 (n7602 n8721 n4260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4276 (n4259 n4260 n4253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4272 (n2284 n8651 n4255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4270 (n10012 n8705 n4256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4269 (n4255 n4256 n4254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4190 (n4191 n4192 n4190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4218 (n4216 n4217 n4193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4245 (n4235 n4236 n4234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4263 (n10017 n8309 n4247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4260 (n17 n8337 n4248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4259 (n4247 n4248 n4246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4256 (n10023 n7667 n4243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4254 (n9031 n7907 n4244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4253 (n4243 n4244 n4237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4250 (n10029 n7645 n4239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4248 (n9715 n7843 n4240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4247 (n4239 n4240 n4238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4237 (n10040 n8893 n4231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4240 (n34 n8871 n4230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4236 (n4230 n4231 n4226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2191 (n8551 n9360 n2199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2134 (n8893 n117 n2161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7378 (n19 n9878 n6362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7377 (n8767 n6272 n6363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7376 (n6362 n6363 n6631 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7354 (n9047 n9878 n6344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7353 (n7545 n8779 n6345 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7352 (n6344 n6345 n6625 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7326 (n7576 n9878 n6323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7324 (n6323 n6324 n6618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7325 (n6272 n8785 n6324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7255 (n6272 n8819 n6271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7254 (n6270 n6271 n6600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7256 (n9692 n9878 n6270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7274 (n7523 n9878 n6284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7273 (n9876 n8811 n6285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7272 (n6284 n6285 n6605 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7270 (n7583 n9878 n6281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7269 (n9877 n8813 n6282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7268 (n6281 n6282 n6604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7250 (n19 n7475 n6266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7249 (n9882 n7763 n6267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7248 (n6266 n6267 n6599 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5472 (n19 n9948 n5069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5471 (n9946 n8599 n5070 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5470 (n5069 n5070 n7015 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7232 (n9852 n7475 n6254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7231 (n9883 n8825 n6255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7230 (n6254 n6255 n6593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7211 (n7773 n7475 n6240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7209 (n6240 n6241 n6586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7210 (n9883 n9580 n6241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7172 (n9412 n7475 n6214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7171 (n9885 n8843 n6215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7170 (n6214 n6215 n6573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7169 (n13 n7475 n6212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7168 (n9884 n8845 n6213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7167 (n6212 n6213 n6572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7150 (n8267 n7479 n6199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7149 (n9886 n8243 n6200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7148 (n6199 n6200 n6567 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7132 (n9047 n7479 n6187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7131 (n9783 n8855 n6188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7130 (n6187 n6188 n6561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7111 (n9705 n7479 n6173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7110 (n9887 n9596 n6174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7109 (n6173 n6174 n6554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7072 (n7559 n7479 n6147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7071 (n9782 n9267 n6148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7070 (n6147 n6148 n6541 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7385 (n10122 write_data\<31\> n6366 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7355 (n10122 write_data\<25\> n6346 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7327 (n10122 write_data\<18\> n6325 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7275 (write_data\<5\> n10122 n6286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7271 (n10122 write_data\<4\> n6283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7374 (n9868 n9878 n6359 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7373 (n7545 n8769 n6360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7372 (n6359 n6360 n6630 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7362 (n9858 n9878 n6350 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7361 (n9876 n8775 n6351 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7360 (n6350 n6351 n6627 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7346 (n9051 n9878 n6338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7345 (n9880 n8783 n6339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7344 (n6338 n6339 n6623 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7282 (n9024 n9878 n6290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7280 (n6290 n6291 n6607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7281 (n9880 n8807 n6291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7278 (n9808 n9878 n6287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7277 (n9879 n8809 n6288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7276 (n6287 n6288 n6606 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7247 (n9694 n7475 n6264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7246 (n9885 n9574 n6265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7245 (n6264 n6265 n6598 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7238 (n9040 n7475 n6258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7237 (n9882 n8821 n6259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7236 (n6258 n6259 n6595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7226 (n9846 n7475 n6250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7225 (n8829 n9884 n6251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7224 (n6250 n6251 n6591 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7178 (n9025 n7475 n6218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7177 (n8839 n7770 n6219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7176 (n6218 n6219 n6575 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7175 (n9808 n7475 n6216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7173 (n6216 n6217 n6574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7174 (n9882 n8841 n6217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7147 (n9034 n7479 n6197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7146 (n9590 n7533 n6198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7145 (n6197 n6198 n6566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7138 (n9040 n7479 n6191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7137 (n9431 n8851 n6192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7136 (n6191 n6192 n6563 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7126 (n9052 n7479 n6183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7124 (n6183 n6184 n6559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7125 (n8859 n7533 n6184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7078 (n7558 n7479 n6151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7077 (n7549 n9263 n6152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7076 (n6151 n6152 n6543 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7075 (n12 n7479 n6149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7073 (n6149 n6150 n6542 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7074 (n7549 n9265 n6150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7047 (n9867 n9891 n6130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7046 (n9784 n9606 n6131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7045 (n6130 n6131 n6534 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7375 (n7482 write_data\<30\> n6361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7363 (n7482 write_data\<27\> n6352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7347 (n7482 write_data\<23\> n6340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7283 (write_data\<7\> n7482 n6292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7279 (n7482 write_data\<6\> n6289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7370 (n9865 n9878 n6356 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7369 (n9877 n8771 n6357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7368 (n6356 n6357 n6629 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7366 (n10195 n9878 n6353 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7365 (n9880 n8773 n6354 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7364 (n6353 n6354 n6628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7342 (n93 n9878 n6335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7341 (n9881 n8239 n6336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7340 (n6335 n6336 n6622 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7334 (n8269 n9878 n6329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7333 (n9879 n9233 n6330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7332 (n6329 n6330 n6620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7330 (n9375 n9878 n6326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7328 (n6326 n6327 n6619 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7329 (n9877 n9235 n6327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7322 (n7543 n9878 n6320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7320 (n6320 n6321 n6617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7321 (n9880 n8787 n6321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7337 (n9880 n9231 n6333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7336 (n6332 n6333 n6621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7338 (n69 n9878 n6332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7358 (n10193 n9878 n6347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7356 (n6347 n6348 n6626 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7357 (n9879 n8777 n6348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7310 (n7578 n9878 n6311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7309 (n9876 n8793 n6312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7308 (n6311 n6312 n6614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7312 (n6314 n6315 n6615 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7314 (n7577 n9878 n6314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7313 (n9876 n8791 n6315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7367 (write_data\<28\> nreset n6355 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7339 (n7580 write_data\<21\> n6334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7359 (n7580 write_data\<26\> n6349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7303 (nreset write_data\<12\> n6307 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7371 (nreset write_data\<29\> n6358 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7343 (write_data\<22\> nreset n6337 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7335 (nreset write_data\<20\> n6331 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7331 (nreset write_data\<19\> n6328 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7323 (write_data\<17\> nreset n6322 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7311 (write_data\<14\> nreset n6313 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U7229 (n9701 n7475 n6252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7228 (n9883 n8827 n6253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7227 (n6252 n6253 n6592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7205 (n10183 n7475 n6236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7203 (n6236 n6237 n6584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7159 (n9882 n9251 n6207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7204 (n9584 n9882 n6237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7160 (n9795 n7475 n6206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7158 (n6206 n6207 n6569 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3513 (n7767 n9251 n3527 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3514 (n10045 n9237 n3526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3512 (n3526 n3527 n3525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3517 (n9275 n34 n3528 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3516 (n9391 n9299 n3529 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3515 (n3528 n3529 n3524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3486 (n3498 n3499 n3497 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3503 (n3516 n3517 n3500 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3510 (n10054 n9341 n3522 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3509 (n10059 n9355 n3523 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3508 (n3522 n3523 n3518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3507 (n7585 n9313 n3520 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3506 (n10066 n9327 n3521 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3505 (n3520 n3521 n3519 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3488 (n3502 n3503 n3501 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3502 (n7603 n8099 n3514 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3501 (n9728 n8759 n3515 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3500 (n3514 n3515 n3510 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3499 (n9726 n8031 n3512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3498 (n8271 n8065 n3513 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3497 (n3512 n3513 n3511 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3495 (n10085 n7759 n3508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3494 (n10091 n8235 n3509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3493 (n3508 n3509 n3504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3492 (n10095 n7715 n3506 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3491 (n10099 n8173 n3507 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3490 (n3506 n3507 n3505 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3532 (n3544 n3545 n3530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3546 (n9993 n9145 n3556 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3545 (n9996 n9153 n3557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3544 (n3556 n3557 n3552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3543 (n9127 n9873 n3554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3542 (n9137 n9759 n3555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3541 (n3554 n3555 n3553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3539 (n8272 n7963 n3550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3538 (n9756 n7997 n3551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3537 (n3550 n3551 n3546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3536 (n9755 n9161 n3548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3535 (n9751 n7929 n3549 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3534 (n3548 n3549 n3547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7351 (n7373 write_data\<24\> n6343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7319 (write_data\<16\> n7373 n6319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7307 (n7373 write_data\<13\> n6310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7350 (n9048 n9878 n6341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7349 (n9877 n8781 n6342 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7348 (n6341 n6342 n6624 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7284 (n6293 n6294 n6608 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7286 (n7557 n9878 n6293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7285 (n9877 n8805 n6294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7266 (n7508 n9878 n6278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7265 (n9881 n8815 n6279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7264 (n6278 n6279 n6603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7181 (n9409 n7475 n6220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7180 (n7770 n9247 n6221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7179 (n6220 n6221 n6576 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7166 (n9800 n7475 n6210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7165 (n9883 n8847 n6211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7164 (n6210 n6211 n6571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7155 (n6203 n6204 n6568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7157 (n9691 n7475 n6203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6757 (n9691 n73 n5935 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6755 (n5935 n5936 n6440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7156 (n9883 n8849 n6204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7081 (n9810 n7479 n6153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7066 (n7561 n7479 n6143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7064 (n6143 n6144 n6539 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7080 (n9886 n9261 n6154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7079 (n6153 n6154 n6544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7065 (n9271 n9886 n6144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6981 (n9810 n9891 n6086 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6966 (n7561 n9891 n6076 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6980 (n9784 n9285 n6087 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6979 (n6086 n6087 n6512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6965 (n9890 n9295 n6077 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6964 (n6076 n6077 n6507 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6881 (n9409 n81 n6019 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6866 (n7508 n81 n6009 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6880 (n35 n9309 n6020 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6879 (n6019 n6020 n6480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6865 (n9894 n8921 n6010 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6864 (n6009 n6010 n6475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6781 (n9409 n73 n5952 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6780 (n9897 n9323 n5953 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6779 (n5952 n5953 n6448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6766 (n9413 n73 n5942 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6765 (n9896 n8951 n5943 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6764 (n5942 n5943 n6443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6756 (n9896 n8953 n5936 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6681 (n7522 n82 n5885 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6666 (n7508 n82 n5875 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6680 (n9899 n9337 n5886 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6679 (n5885 n5886 n6416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6665 (n9900 n8981 n5876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6664 (n5875 n5876 n6411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6583 (n9810 n77 n5818 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6568 (n9800 n77 n5808 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6582 (n9903 n9351 n5819 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6581 (n5818 n5819 n6384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6567 (n9435 n9011 n5809 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6566 (n5808 n5809 n6379 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7287 (nreset write_data\<8\> n6295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7267 (write_data\<3\> nreset n6280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6483 (n7582 n9908 n5751 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7318 (n9831 n9878 n6317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7317 (n9881 n8789 n6318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7316 (n6317 n6318 n6616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6507 (n9831 n9908 n5767 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6506 (n9907 n7446 n5768 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6505 (n5767 n5768 n7352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5721 (n9831 n79 n5237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5720 (n9934 n8467 n5238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5719 (n5237 n5238 n7096 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5623 (n9831 n9939 n5171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5622 (n8521 n9936 n5172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5621 (n5171 n5172 n7064 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5133 (n9831 n9962 n4839 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5132 (n9484 n9958 n4840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5131 (n4839 n4840 n6904 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4741 (n9831 n9978 n4571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4740 (n7531 n9548 n4572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4739 (n4571 n4572 n6776 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3802 (n9991 n8521 n3808 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3801 (n7589 n8577 n3809 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3800 (n3808 n3809 n3804 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3798 (n9401 n8467 n3807 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3799 (n9765 n9117 n3806 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3797 (n3806 n3807 n3805 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3742 (n3750 n3751 n3749 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3788 (n3796 n3797 n3782 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3794 (n9399 n9484 n3803 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3795 (n10004 n9468 n3802 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3793 (n3802 n3803 n3798 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3792 (n9398 n8621 n3800 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3791 (n9396 n8675 n3801 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3790 (n3800 n3801 n3799 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3775 (n3784 n3785 n3783 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3786 (n7587 n9446 n3794 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3785 (n9394 n8321 n3795 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3784 (n3794 n3795 n3793 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3782 (n2269 n7653 n3790 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3781 (n7575 n7893 n3791 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3780 (n3790 n3791 n3786 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3779 (n10030 n7629 n3788 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3778 (n9030 n7829 n3789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3777 (n3788 n3789 n3787 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3761 (n3772 n3773 n3771 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3763 (n9388 n9632 n3772 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3759 (n3768 n3769 n3752 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3773 (n9743 n9600 n3780 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3772 (n10040 n9616 n3781 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3771 (n3780 n3781 n3776 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3770 (n2251 n8789 n3778 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1667 (n8789 n8263 n1708 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1665 (n1708 n1709 n1707 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1666 (n9584 n48 n1709 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3769 (n9738 n9584 n3779 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3768 (n3778 n3779 n3777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3766 (n33 n9664 n3774 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3765 (n9390 n9680 n3775 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3764 (n3774 n3775 n3770 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1699 (n8521 n9360 n1738 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1695 (n8467 n9017 n1737 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1691 (n9484 n95 n1733 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7306 (n9712 n9878 n6308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7196 (n9712 n7475 n6230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7305 (n8795 n9881 n6309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7304 (n6308 n6309 n6613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7296 (n6302 n6303 n6611 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7298 (n10178 n9878 n6302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7297 (n9881 n8799 n6303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7294 (n18 n9878 n6299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7293 (n7545 n8801 n6300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7292 (n6299 n6300 n6610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7290 (n7495 n9878 n6296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7288 (n6296 n6297 n6609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7289 (n7545 n8803 n6297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7258 (n7545 n9237 n6274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7259 (n7507 n9878 n6273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7257 (n6273 n6274 n6601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7302 (n7521 n9878 n6305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7301 (n9879 n8797 n6306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7300 (n6305 n6306 n6612 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7262 (n9414 n9878 n6275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7260 (n6275 n6276 n6602 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7261 (n9879 n8817 n6276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7195 (n9884 n8831 n6231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7194 (n6230 n6231 n6581 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7193 (n9820 n7475 n6228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7192 (n7770 n8833 n6229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7191 (n6228 n6229 n6580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7190 (n9817 n7475 n6226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7189 (n9430 n8835 n6227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7188 (n6226 n6227 n6579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7187 (n18 n7475 n6224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7185 (n6224 n6225 n6578 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7186 (n7770 n8837 n6225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7201 (n7770 n9586 n6235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7200 (n6234 n6235 n6583 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7202 (n9827 n7475 n6234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7184 (n9408 n7475 n6222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7183 (n9885 n9245 n6223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7182 (n6222 n6223 n6577 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7163 (n9414 n7475 n6208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7161 (n6208 n6209 n6570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7162 (n9430 n9249 n6209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7093 (n9820 n7479 n6161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7092 (n7533 n8865 n6162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7091 (n6161 n6162 n6548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7090 (n9819 n7479 n6159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7089 (n9782 n8867 n6160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7088 (n6159 n6160 n6547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7087 (n9407 n7479 n6157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7085 (n6157 n6158 n6546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7086 (n7533 n8869 n6158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7295 (n7580 write_data\<10\> n6301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7299 (write_data\<11\> n7580 n6304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7291 (n7580 write_data\<9\> n6298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7263 (write_data\<2\> n7580 n6277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7242 (n6262 n6263 n6597 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7244 (n9696 n7475 n6262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7220 (n9843 n7475 n6246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7219 (n9239 n9885 n6247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7243 (n9885 n9576 n6263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7218 (n6246 n6247 n6589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7118 (n6179 n6180 n6557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7120 (n9843 n7479 n6179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7108 (n9706 n7479 n6171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7107 (n9782 n9598 n6172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7119 (n9782 n9253 n6180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7106 (n6171 n6172 n6553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6920 (n9843 n81 n6045 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6919 (n7474 n9301 n6046 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6918 (n6045 n6046 n6493 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6844 (n9696 n73 n5994 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6843 (n9898 n9640 n5995 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6842 (n5994 n5995 n6469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6708 (n9706 n82 n5903 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6707 (n9902 n9662 n5904 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6706 (n5903 n5904 n6425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6448 (n9696 n86 n5727 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6447 (n9438 n9767 n5728 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6446 (n5727 n5728 n7333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6314 (n9706 n89 n5637 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6313 (n90 n9456 n5638 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6312 (n5637 n5638 n7289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6130 (n9843 n75 n5513 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6129 (n7477 n9091 n5514 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6128 (n5513 n5514 n7229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6056 (n9696 n8278 n5463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6020 (n9706 n8278 n5439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6055 (n9416 n7849 n5464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6054 (n5463 n5464 n7205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6019 (n7565 n7651 n5440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6018 (n5439 n5440 n7193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5332 (n9706 n9953 n4975 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5331 (n9773 n8673 n4976 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5330 (n4975 n4976 n6969 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5564 (n9696 n9944 n5131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5563 (n8557 n7526 n5132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5562 (n5131 n5132 n7045 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5270 (n9696 n7472 n4933 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5246 (n9843 n7472 n4917 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5269 (n9954 n9460 n4934 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5268 (n4933 n4934 n6949 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5245 (n9956 n7943 n4918 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5244 (n4917 n4918 n6941 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4952 (n9843 n7473 n4715 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4951 (n9968 n8045 n4716 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4950 (n4715 n4716 n6845 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3721 (n9393 n9456 n3732 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3720 (n3731 n3732 n3730 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3722 (n9395 n9444 n3731 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3711 (n3721 n3722 n3720 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3718 (n9392 n7651 n3727 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3717 (n9032 n7891 n3728 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3716 (n3727 n3728 n3723 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1618 (n9456 n115 n1662 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1615 (n7651 n66 n1657 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7241 (n9697 n7475 n6260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7240 (n9430 n9578 n6261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7239 (n6260 n6261 n6596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6741 (n9697 n82 n5925 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6740 (n9434 n9658 n5926 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6739 (n5925 n5926 n6436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6347 (n9697 n89 n5659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6346 (n7590 n8313 n5660 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6345 (n5659 n5660 n7300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6053 (n9697 n72 n5461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6052 (n9415 n7851 n5462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6051 (n5461 n5462 n7204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2953 (n7765 n8313 n2976 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2952 (n2975 n2976 n2974 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2954 (n7587 n9440 n2975 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2943 (n2965 n2966 n2964 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2950 (n10023 n7851 n2971 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2949 (n7575 n8379 n2972 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2948 (n2971 n2972 n2967 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2947 (n2265 n7621 n2969 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2946 (n7547 n8345 n2970 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2945 (n2969 n2970 n2968 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2910 (n2931 n2932 n2930 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2912 (n2935 n2936 n2934 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2956 (n2977 n2978 n2963 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2970 (n9763 n8505 n2989 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2969 (n9761 n8559 n2990 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2968 (n2989 n2990 n2985 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2967 (n8413 n9873 n2987 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2966 (n10000 n8451 n2988 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2965 (n2988 n2987 n2986 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2963 (n9757 n9462 n2983 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2962 (n9756 n9478 n2984 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2961 (n2983 n2984 n2979 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2960 (n10009 n8605 n2981 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2959 (n9751 n8659 n2982 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2958 (n2981 n2982 n2980 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2927 (n2949 n2950 n2933 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2941 (n9743 n9594 n2961 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2940 (n10041 n9610 n2962 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2939 (n2961 n2962 n2957 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2937 (n7767 n9578 n2960 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U834 (n9578 n48 n890 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U833 (n889 n890 n888 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U835 (n8773 n8263 n889 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2938 (n9739 n8773 n2959 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2936 (n2959 n2960 n2958 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2934 (n2245 n9658 n2955 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2933 (n31 n9674 n2956 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2932 (n2955 n2956 n2951 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2931 (n9388 n9626 n2953 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2930 (n7766 n9642 n2954 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2929 (n2953 n2954 n2952 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2926 (n10069 n9526 n2947 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2925 (n10073 n9542 n2948 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2924 (n2947 n2948 n2943 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U850 (n8313 n115 n906 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U847 (n7851 n66 n901 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U831 (n9658 n119 n885 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7235 (n9044 n7475 n6256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7234 (n8823 n9430 n6257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7233 (n6256 n6257 n6594 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7135 (n9044 n7479 n6189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7134 (n8853 n9431 n6190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7133 (n6189 n6190 n6562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5065 (n9044 n9964 n4792 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5064 (n9421 n8001 n4793 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5063 (n4792 n4793 n6882 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4771 (n9044 n9978 n4591 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4770 (n9976 n8103 n4592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4769 (n4591 n4592 n6786 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4477 (n9044 n9986 n4389 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4476 (n9987 n7729 n4390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4475 (n4389 n4390 n6690 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3069 (n10038 n8853 n3087 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3068 (n10041 n8875 n3088 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3067 (n3087 n3088 n3083 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3065 (n8823 n10052 n3086 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U962 (n8823 n48 n1016 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U961 (n1015 n1016 n1014 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U963 (n8777 n8263 n1015 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3066 (n10046 n8777 n3085 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3064 (n3085 n3086 n3084 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3038 (n3057 n3058 n3056 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3055 (n3075 n3076 n3059 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3062 (n9737 n8957 n3081 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3061 (n10058 n8987 n3082 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3060 (n3081 n3082 n3077 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3059 (n10062 n8897 n3079 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3058 (n10065 n8927 n3080 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3057 (n3079 n3080 n3078 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3040 (n3061 n3062 n3060 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3053 (n8103 n10073 n3074 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3054 (n10069 n8069 n3073 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3052 (n3073 n3074 n3069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3051 (n10077 n8001 n3071 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3050 (n10081 n8035 n3072 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3049 (n3071 n3072 n3070 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3047 (n10084 n7729 n3067 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3046 (n10089 n8205 n3068 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3045 (n3067 n3068 n3063 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3044 (n10094 n7681 n3065 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3043 (n26 n8139 n3066 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3042 (n3065 n3066 n3064 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3084 (n3103 n3104 n3089 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3098 (n9991 n8509 n3115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3097 (n9995 n8563 n3116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3096 (n3115 n3116 n3111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3095 (n8417 n9873 n3113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3094 (n10000 n8455 n3114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3093 (n3113 n3114 n3112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3091 (n10003 n7933 n3109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3090 (n7602 n7967 n3110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3089 (n3109 n3110 n3105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3088 (n9397 n8609 n3107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3087 (n10012 n8663 n3108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3086 (n3107 n3108 n3106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U966 (n8853 n109 n1017 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U950 (n8103 n107 n1004 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U948 (n8001 n10114 n1001 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U944 (n7729 n123 n997 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7223 (n9845 n7475 n6248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7222 (n9884 n8241 n6249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7221 (n6248 n6249 n6590 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6427 (n9845 n86 n5713 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6426 (n9909 n7781 n5714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6425 (n5713 n5714 n7326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5837 (n9845 n9932 n5315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5836 (n8425 n9928 n5316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5835 (n5315 n5316 n7134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5739 (n9845 n79 n5249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5738 (n9419 n7911 n5250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5737 (n5249 n5250 n7102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3351 (n9873 n8425 n3365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3350 (n7911 n10000 n3366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3349 (n3365 n3366 n3364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3354 (n9763 n7913 n3367 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3353 (n9995 n8571 n3368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3352 (n3367 n3368 n3363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3340 (n3355 n3356 n3341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3347 (n9757 n7941 n3361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3346 (n10007 n7975 n3362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3345 (n3361 n3362 n3357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3344 (n9754 n7925 n3359 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3343 (n9751 n7927 n3360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3342 (n3359 n3360 n3358 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3327 (n3343 n3344 n3342 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3338 (n9749 n7781 n3353 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3337 (n9394 n7613 n3354 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3336 (n3353 n3354 n3352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3334 (n9746 n7647 n3349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3333 (n7575 n7887 n3350 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3332 (n3349 n3350 n3345 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3331 (n10030 n7623 n3347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3330 (n9714 n7823 n3348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3329 (n3347 n3348 n3346 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3296 (n3313 n3314 n3312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3305 (n3323 n3324 n3322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3294 (n3309 n3310 n3308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3311 (n3327 n3328 n3311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3325 (n7586 n8861 n3339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3324 (n2254 n8883 n3340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3323 (n3339 n3340 n3335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3321 (n9738 n8241 n3338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1218 (n8241 n48 n1268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1217 (n1267 n1268 n1266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1219 (n8239 n8263 n1267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3322 (n9739 n8239 n3337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3320 (n3337 n3338 n3336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3318 (n8257 n10056 n3333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3317 (n10060 n8261 n3334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3316 (n3333 n3334 n3329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3315 (n10062 n8249 n3331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3314 (n10066 n8253 n3332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3313 (n3331 n3332 n3330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3310 (n2233 n8077 n3325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3309 (n9727 n7669 n3326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3308 (n3325 n3326 n3321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1248 (n8425 n10203 n1295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1247 (n7911 n9017 n1296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1246 (n1295 n1296 n1294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7215 (n6244 n6245 n6588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7217 (n7520 n7475 n6244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7214 (n9704 n7475 n6242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7213 (n9430 n9243 n6243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7216 (n9430 n9241 n6245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7212 (n6242 n6243 n6587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6917 (n7520 n81 n6043 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6916 (n7474 n9303 n6044 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6915 (n6043 n6044 n6492 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6714 (n9704 n82 n5907 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6713 (n9900 n9333 n5908 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6712 (n5907 n5908 n6427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6418 (n9704 n86 n5707 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6417 (n9403 n9061 n5708 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6416 (n5707 n5708 n7323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6127 (n7520 n75 n5511 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6126 (n9769 n9093 n5512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6125 (n5511 n5512 n7228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5828 (n9704 n9932 n5309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5827 (n9930 n9111 n5310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5826 (n5309 n5310 n7131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5240 (n9704 n7472 n4913 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5239 (n9955 n7947 n4914 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5238 (n4913 n4914 n6939 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4554 (n9704 n9983 n4443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4553 (n9982 n8153 n4444 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4552 (n4443 n4444 n6715 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4851 (n7520 n9974 n4646 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4850 (n9971 n8081 n4647 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4849 (n4646 n4647 n6812 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4363 (n7520 n131 n4312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4362 (n7496 n8213 n4313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4361 (n4312 n4313 n6652 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3607 (n9874 n9111 n3617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3606 (n7588 n9135 n3618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3605 (n3617 n3618 n3616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3610 (n9764 n9143 n3619 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3609 (n9995 n9151 n3620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3608 (n3619 n3620 n3615 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3550 (n3561 n3562 n3560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3596 (n3607 n3608 n3593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3603 (n10004 n7947 n3613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3602 (n27 n7981 n3614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3601 (n3613 n3614 n3609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3600 (n2284 n9159 n3611 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3599 (n10013 n9167 n3612 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3598 (n3611 n3612 n3610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3583 (n3595 n3596 n3594 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3594 (n7587 n9061 n3605 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3593 (n7765 n9075 n3606 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3592 (n3605 n3606 n3604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3590 (n10025 n7867 n3601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3589 (n7575 n9103 n3602 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3588 (n3601 n3602 n3597 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3587 (n10031 n7805 n3599 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3586 (n9714 n9095 n3600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3585 (n3599 n3600 n3598 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1504 (n9111 n10203 n1547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1500 (n7947 n64 n1543 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7208 (n9707 n7475 n6238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7199 (n7775 n7475 n6232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7197 (n6232 n6233 n6582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7207 (n9884 n9582 n6239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7206 (n6238 n6239 n6585 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7198 (n9884 n9588 n6233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7008 (n9707 n9891 n6104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7007 (n9889 n9614 n6105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7006 (n6104 n6105 n6521 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6808 (n9707 n73 n5970 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6807 (n9786 n9646 n5971 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6806 (n5970 n5971 n6457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6610 (n9707 n77 n5836 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6609 (n9904 n9678 n5837 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6608 (n5836 n5837 n6393 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6412 (n9707 n86 n5703 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6411 (n9444 n7769 n5704 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6410 (n5703 n5704 n7321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1619 (n9444 n103 n1661 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1617 (n1661 n1662 n1660 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1613 (n1657 n1658 n1653 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1614 (n7891 n97 n1658 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1608 (n1651 n1652 n1650 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1612 (n7627 n40 n1655 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1611 (n7827 n9359 n1656 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1610 (n1655 n1656 n1654 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1630 (n1673 n1674 n1672 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1632 (n9115 n10203 n1673 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3735 (n9873 n9115 n3743 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1623 (n1667 n1668 n1666 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1625 (n8619 n68 n1667 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3728 (n9397 n8619 n3737 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1621 (n1663 n1664 n1649 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1635 (n8519 n9360 n1675 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3738 (n9764 n8519 n3745 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1634 (n8575 n105 n1676 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3737 (n9995 n8575 n3746 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1633 (n1675 n1676 n1671 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3736 (n3745 n3746 n3741 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3734 (n9400 n8465 n3744 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3733 (n3743 n3744 n3742 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1631 (n8465 n9017 n1674 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1628 (n9466 n64 n1669 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3731 (n10005 n9466 n3739 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1627 (n9482 n95 n1670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3730 (n27 n9482 n3740 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1626 (n1669 n1670 n1665 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3729 (n3739 n3740 n3735 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3724 (n3733 n3734 n3719 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3726 (n3737 n3738 n3736 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3727 (n9396 n8673 n3738 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1624 (n8673 n212 n1668 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3678 (n3687 n3688 n3686 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3695 (n3705 n3706 n3689 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3708 (n9391 n9614 n3718 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1605 (n9614 n117 n1648 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1604 (n1647 n1648 n1643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1606 (n9598 n109 n1647 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3709 (n10037 n9598 n3717 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3707 (n3717 n3718 n3713 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7142 (n6195 n6196 n6565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7144 (n9035 n7479 n6195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7057 (n9692 n7479 n6136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7056 (n7533 n8871 n6137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7143 (n7533 n9592 n6196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7055 (n6136 n6137 n6536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2137 (n8871 n109 n2160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2133 (n2160 n2161 n2156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2131 (n8819 n8263 n2158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4234 (n10045 n8819 n4228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2129 (n8849 n48 n2159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4232 (n10050 n8849 n4229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2128 (n2158 n2159 n2157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4231 (n4228 n4229 n4227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2117 (n2150 n2151 n2149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2120 (n8923 n111 n2150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4223 (n10063 n8923 n4220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2087 (n2121 n2122 n2120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2115 (n2146 n2147 n2123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2125 (n8983 n119 n2154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4228 (n10056 n8983 n4224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2123 (n9013 n99 n2155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4226 (n9735 n9013 n4225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2122 (n2154 n2155 n2148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4225 (n4224 n4225 n4218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4220 (n4220 n4221 n4219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4221 (n8953 n2240 n4221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2118 (n8953 n113 n2151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2102 (n2139 n2140 n2138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2105 (n8729 n10114 n2139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4208 (n10076 n8729 n4209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2089 (n2125 n2126 n2124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2112 (n8745 n121 n2142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4215 (n10068 n8745 n4212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2109 (n8761 n107 n2143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4212 (n9728 n8761 n4213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2108 (n2142 n2143 n2137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4211 (n4212 n4213 n4207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4206 (n10080 n8737 n4210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4205 (n4209 n4210 n4208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2103 (n8737 n10116 n2140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2099 (n7761 n123 n2134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4202 (n9722 n7761 n4204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2097 (n8237 n52 n2135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4200 (n10089 n8237 n4205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2096 (n2134 n2135 n2127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4199 (n4204 n4205 n4197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4192 (n4195 n4196 n4194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4194 (n4199 n4200 n4198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4197 (n10093 n7717 n4199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2094 (n7717 n125 n2129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2092 (n8175 n57 n2130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2091 (n2129 n2130 n2128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4195 (n26 n8175 n4200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2187 (n2199 n2200 n2192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2188 (n8597 n105 n2200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2166 (n2185 n2186 n2184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2169 (n8651 n68 n2185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2164 (n2181 n2182 n2163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2184 (n9129 n10203 n2194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2182 (n8497 n9017 n2195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2181 (n2194 n2195 n2193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2176 (n8713 n64 n2189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2174 (n8721 n95 n2190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U2173 (n2189 n2190 n2183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7141 (n9037 n7479 n6193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7063 (n9798 n7479 n6141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7140 (n9886 n9594 n6194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7062 (n9886 n9273 n6142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7139 (n6193 n6194 n6564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7061 (n6141 n6142 n6538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U838 (n9594 n109 n891 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U837 (n9610 n117 n892 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U824 (n879 n880 n863 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U807 (n861 n862 n860 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U836 (n891 n892 n887 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U829 (n885 n886 n881 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U830 (n9674 n99 n886 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U828 (n9626 n111 n883 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U827 (n9642 n113 n884 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U826 (n883 n884 n882 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U809 (n865 n866 n864 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U823 (n9526 n121 n877 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U822 (n9542 n107 n878 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U821 (n877 n878 n873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U820 (n9494 n10114 n875 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U819 (n9510 n10116 n876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U818 (n875 n876 n874 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U816 (n7725 n123 n871 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U815 (n52 n8201 n872 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U814 (n871 n872 n867 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U813 (n7677 n125 n869 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U812 (n8135 n57 n870 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U811 (n869 n870 n868 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U840 (n895 n896 n894 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U845 (n901 n902 n897 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U846 (n8379 n97 n902 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U853 (n907 n908 n893 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U867 (n8505 n9360 n919 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U866 (n8559 n105 n920 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U865 (n919 n920 n915 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U864 (n8413 n10203 n917 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U863 (n8451 n9017 n918 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U862 (n917 n918 n916 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U860 (n9462 n64 n913 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U859 (n9478 n95 n914 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U858 (n913 n914 n909 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U857 (n8605 n68 n911 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U856 (n8659 n8264 n912 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U855 (n911 n912 n910 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U849 (n905 n906 n904 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U851 (n9440 n101 n905 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U844 (n7621 n40 n899 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U843 (n8345 n9359 n900 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U842 (n899 n900 n898 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U805 (n858 n859 read_data_2\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U868 (write_data\<28\> n36 n858 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U806 (n860 n10120 n859 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7129 (n9049 n7479 n6185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7069 (n13 n7479 n6145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7128 (n9431 n8857 n6186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7068 (n9431 n9269 n6146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7127 (n6185 n6186 n6560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7067 (n6145 n6146 n6540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6929 (n9049 n81 n6051 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6928 (n9785 n8901 n6052 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6927 (n6051 n6052 n6496 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6669 (n13 n82 n5877 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6668 (n9900 n8979 n5878 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6667 (n5877 n5878 n6412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5883 (n13 n9924 n5346 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5882 (n9921 n8401 n5347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5881 (n5346 n5347 n7148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5059 (n9049 n9964 n4788 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4999 (n13 n9964 n4748 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4997 (n4748 n4749 n6860 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5058 (n9965 n8005 n4789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U5057 (n4788 n4789 n6880 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4998 (n9965 n8027 n4749 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4607 (n13 n7778 n4480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4606 (n9778 n7711 n4481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4605 (n4480 n4481 n6732 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4765 (n9049 n9978 n4587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4764 (n9975 n8107 n4588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4763 (n4587 n4588 n6784 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4471 (n9049 n9986 n4385 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4470 (n9987 n7733 n4386 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U4469 (n4385 n4386 n6688 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3197 (n10038 n8857 n3213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3196 (n9741 n8879 n3214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3195 (n3213 n3214 n3209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3194 (n10047 n8781 n3211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1091 (n8781 n8263 n1141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1089 (n1141 n1142 n1140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3193 (n10051 n8827 n3212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U3192 (n3211 n3212 n3210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1090 (n8827 n48 n1142 inh_gnd inh_gnds inh_vdd inh_vdds) \
