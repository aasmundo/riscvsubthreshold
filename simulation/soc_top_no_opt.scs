    register_a_reg_12__25_ (clk n7009 NeTt_28029 n8612 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_20__7_ (clk n6735 NeTt_28030 n7706 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_20__5_ (clk n6733 NeTt_28031 n7710 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_23__6_ (clk n6638 NeTt_28032 n8228 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_23__5_ (clk n6637 NeTt_28033 n8230 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_11__25_ (clk n7041 NeTt_28034 n8566 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_11__6_ (clk n7022 NeTt_28035 n7918 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_15__25_ (clk n6913 NeTt_28036 n7970 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_15__6_ (clk n6894 NeTt_28037 n7990 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_22__8_ (clk n6672 NeTt_28038 n8194 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_22__12_ (clk n6676 NeTt_28039 n7744 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    register_a_reg_20__11_ (clk n6739 NeTt_28040 n7702 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U9236 (write_register\<3\> n10206 n10158 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9235 (read_register_2\<3\> n58 n10159 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9237 (n10158 n10159 n10160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9239 (n10162 n10163 N237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9227 (n10151 n10166 n10155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9233 (write_register\<4\> n10165 n10156 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9232 (read_register_2\<4\> n10167 n10157 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9234 (n10157 n10156 n10161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9228 (read_register_2\<2\> n9789 n10153 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9229 (n49 n10164 n10152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9230 (n10152 n10153 n10154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9224 (write_register\<1\> n10148 n10150 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9225 (n10148 n7480 n10149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9226 (n10150 n10149 n10151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9210 (read_register_1\<4\> n10167 n10136 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9211 (write_register\<4\> n10209 n10135 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9212 (n10136 n10135 n10140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9205 (n10130 n10143 n10134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4302 (n4272 n7368 n4274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9217 (n10142 n10141 N230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9213 (n58 read_register_1\<3\> n10138 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9214 (n10213 n11 n10137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9215 (n10138 n10137 n10139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9206 (read_register_1\<2\> n9789 n10132 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U9207 (n49 n8 n10131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9208 (n10131 n10132 n10133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9203 (n10127 n41 n10128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9202 (n10127 n9788 n10129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9204 (n10128 n10129 n10130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2198 (n2203 n132 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2106 (n2141 n45 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U532 (n205 n7401 n588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U528 (n588 n589 n580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U521 (n582 n583 n581 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7398 (n10201 n130 n6374 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6854 (n7579 n9788 n6001 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6754 (n10201 n8268 n5934 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2186 (read_register_2\<4\> n8265 n2198 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2104 (n2131 n10208 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2130 (n2152 n10208 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9201 (n7579 n9793 n10127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9223 (n9791 n130 n10148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4243 (n10213 n10209 n4232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4275 (read_register_1\<1\> n8 n4258 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2202 (read_register_2\<2\> read_register_2\<1\> n2196 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U4493 (n7499 n4401 n4338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4494 (n4403 n7504 n4401 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4788 (n7502 n7553 n4603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5571 (n7481 n5137 n5074 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5572 (n2 n7502 n5137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4787 (n7374 n4603 n4540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4886 (n7492 n43 n4670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5669 (n7499 n5203 n5140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5670 (n2 n7492 n5203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4885 (n7374 n4670 n4607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5179 (n7499 n4871 n4808 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5180 (n2 n7519 n4871 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5375 (n7374 n5005 n4942 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5376 (n2 n7516 n5005 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5473 (n7499 n5071 n5008 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5474 (n2 n7513 n5071 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5865 (n7481 n5335 n5272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5866 (n2 n7535 n5335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5966 (n92 n7518 n5402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6553 (n7481 n5799 n5736 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6554 (n92 n7486 n5799 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5965 (n7499 n5402 n5339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7396 (write_register\<3\> n7368 n6373 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U7051 (n7374 n6134 n6071 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7052 (n4 n7502 n6134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2192 (n2145 n10204 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2146 (n2171 n50 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2183 (n7572 n45 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2132 (n2153 n45 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6063 (n7481 n5469 n5406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6064 (n92 n7504 n5469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7054 (n7579 n49 n6135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6954 (write_register\<1\> n8268 n6068 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U7154 (n49 n8268 n6202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7382 (write_register\<1\> n22 n6269 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U7394 (n7518 n43 n6372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7393 (n7374 n6372 n4277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6654 (n4 n7519 n5866 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6653 (n7374 n5866 n5803 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4689 (n7481 n4536 n4473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4690 (n7513 n7554 n4536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6357 (n7499 n5667 n5604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6358 (n92 n7501 n5667 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5082 (n7535 n42 n4804 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5081 (n7374 n4804 n4741 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4984 (n4738 n7553 n4737 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4983 (n7481 n4737 n4674 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6260 (n92 n7512 n5601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6259 (n7499 n5601 n5538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6162 (n92 n7515 n5535 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6161 (n7374 n5535 n5472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6852 (n4 n7516 n6000 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6851 (n7499 n6000 n5937 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4592 (n7516 n7554 n4469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4591 (n7481 n4469 n4406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7380 (n4 n7535 n6364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7379 (n7499 n6364 n6272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6952 (n4 n7513 n6067 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6951 (n7374 n6067 n6004 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6455 (n7374 n5733 n5670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7151 (n7499 n6201 n6138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7152 (n4 n7492 n6201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6556 (write_register\<4\> n11 n5800 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U6456 (n92 n7491 n5733 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2203 (read_register_2\<4\> n37 n2179 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2179 (n7480 n10164 n2191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2148 (n2172 n8279 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7252 (n4 n7486 n6268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5768 (n2 n7486 n5269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5767 (n7481 n5269 n5206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U7251 (n7499 n6268 n6205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5278 (n2 n7505 n4939 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6752 (n4 n7505 n5933 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U6751 (n7481 n5933 n5870 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5277 (n7374 n4939 n4876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5868 (write_register\<4\> n132 n5336 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2095 (n2132 n7573 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2100 (n2136 n7573 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2113 (n2145 n7573 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2126 (n2153 n10207 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2135 (n2152 n9363 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2124 (n2152 n7605 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2158 (n2171 n9363 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2189 (n7572 n9363 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2193 (n10206 n38 n2201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2152 (n2171 n7605 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2140 (n10206 n10165 n2162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2119 (n2152 n50 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2172 (read_register_2\<1\> n10164 n2188 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U2161 (n2180 n8279 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2177 (n10204 n2136 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2170 (n2132 n10204 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2154 (n2136 n8279 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2121 (n7607 n16 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1428 (n7469 n7372 n1470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1417 (n1464 n1465 n1463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1424 (n1471 n1470 n1462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1384 (n1430 n1431 n1429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1393 (n1440 n1441 n1432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1415 (n1460 n1461 n1428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1437 (n1482 n1483 n1474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1430 (n1476 n1477 n1475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1401 (n1448 n1449 n1447 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1408 (n1454 n1455 n1446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2138 (n2153 n9362 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2110 (n2131 n9362 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2168 (n7607 n7572 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2098 (n2131 n7606 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2175 (n7572 n7606 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2093 (n2131 n7607 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4283 (n4262 n4263 n4251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4268 (n4253 n4254 n4252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4191 (n4193 n4194 n4192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4230 (n4226 n4227 n4216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4244 (n4233 n4234 n4191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4258 (n4245 n4246 n4235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4266 (n7399 n9367 n4245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4246 (n4237 n4238 n4236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3511 (n3524 n3525 n3516 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3504 (n3518 n3519 n3517 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3487 (n3500 n3501 n3499 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3518 (n3530 n3531 n3498 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3496 (n3510 n3511 n3502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3489 (n3504 n3505 n3503 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3540 (n3552 n3553 n3544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3533 (n3546 n3547 n3545 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3796 (n3804 n3805 n3796 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3789 (n3798 n3799 n3797 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3774 (n3782 n3783 n3750 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3743 (n3752 n3753 n3751 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3787 (n7454 n9020 n3792 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3783 (n3793 n3792 n3784 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3776 (n3786 n3787 n3785 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3767 (n3776 n3777 n3768 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3760 (n3770 n3771 n3769 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3723 (n7455 n62 n3729 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3712 (n3723 n3724 n3722 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3719 (n3729 n3730 n3721 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2955 (n7417 n127 n2973 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2944 (n2967 n2968 n2966 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2951 (n2974 n2973 n2965 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2911 (n2933 n2934 n2932 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2920 (n2943 n2944 n2935 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2942 (n2963 n2964 n2931 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2964 (n2985 n2986 n2977 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2957 (n2979 n2980 n2978 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2935 (n2957 n2958 n2949 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2928 (n2951 n2952 n2950 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3063 (n3083 n3084 n3075 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3056 (n3077 n3078 n3076 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3039 (n3059 n3060 n3058 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3070 (n3089 n3090 n3057 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3048 (n3069 n3070 n3061 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3041 (n3063 n3064 n3062 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3092 (n3111 n3112 n3103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3085 (n3105 n3106 n3104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3348 (n3363 n3364 n3355 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3341 (n3357 n3358 n3356 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3326 (n3341 n3342 n3309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3335 (n3352 n3351 n3343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3339 (n7436 n10015 n3351 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3328 (n3345 n3346 n3344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3295 (n3311 n3312 n3310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3304 (n3321 n3322 n3313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3319 (n3335 n3336 n3327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3312 (n3329 n3330 n3328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3604 (n3615 n3616 n3607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3597 (n3609 n3610 n3608 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3582 (n3593 n3594 n3561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3591 (n3604 n3603 n3595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3595 (n7433 n9018 n3603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3584 (n3597 n3598 n3596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1616 (n1660 n1659 n1651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1620 (n7455 n7471 n1659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1609 (n1653 n1654 n1652 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1607 (n1649 n1650 n1617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1629 (n1671 n1672 n1663 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1622 (n1665 n1666 n1664 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3732 (n3741 n3742 n3733 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3725 (n3735 n3736 n3734 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3679 (n3689 n3690 n3688 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3703 (n3713 n3714 n3705 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3710 (n3719 n3720 n3687 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2127 (n2156 n2157 n2146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2116 (n2148 n2149 n2147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2088 (n2123 n2124 n2122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2141 (n2163 n2164 n2121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4219 (n4218 n4219 n4217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2101 (n2137 n2138 n2125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2090 (n2127 n2128 n2126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4204 (n4207 n4208 n4195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4193 (n4197 n4198 n4196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2180 (n2192 n2193 n2181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2165 (n2183 n2184 n2182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U832 (n887 n888 n879 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U808 (n863 n864 n862 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U825 (n881 n882 n880 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U817 (n873 n874 n865 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U810 (n867 n868 n866 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U841 (n897 n898 n896 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U839 (n893 n894 n861 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U861 (n915 n916 n907 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U854 (n909 n910 n908 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U852 (n7417 n129 n903 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U848 (n903 n904 n895 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3191 (n3209 n3210 n3201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3184 (n3203 n3204 n3202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3167 (n3185 n3186 n3184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3176 (n3195 n3196 n3187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3169 (n3189 n3190 n3188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1216 (n1265 n1266 n1257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1209 (n1259 n1260 n1258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1192 (n1241 n1242 n1240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1201 (n1251 n1252 n1243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1194 (n1245 n1246 n1244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1223 (n1271 n1272 n1239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1245 (n1293 n1294 n1285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1238 (n1287 n1288 n1286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1232 (n1281 n1282 n1273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1236 (n7436 n128 n1281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1225 (n1275 n1276 n1274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1351 (n1397 n1398 n1365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1373 (n1419 n1420 n1411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3456 (n3471 n3472 n3470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3463 (n3477 n3478 n3469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3467 (n7434 n46 n3477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3454 (n3467 n3468 n3435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3423 (n3437 n3438 n3436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3476 (n3489 n3490 n3481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3469 (n3483 n3484 n3482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3447 (n3461 n3462 n3453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3440 (n3455 n3456 n3454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1344 (n1391 n1392 n1383 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1481 (n1527 n1528 n1526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1488 (n1534 n1533 n1525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1492 (n7433 n126 n1533 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1479 (n1523 n1524 n1491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1501 (n1545 n1546 n1537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1494 (n1539 n1540 n1538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1448 (n1493 n1494 n1492 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1472 (n1517 n1518 n1509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3575 (n3587 n3588 n3579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3551 (n3563 n3564 n3562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3568 (n3581 n3582 n3580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3560 (n3573 n3574 n3565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3553 (n3567 n3568 n3566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1664 (n1706 n1707 n1698 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1657 (n1700 n1701 n1699 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1640 (n1682 n1683 n1681 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1649 (n1692 n1693 n1684 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1642 (n1686 n1687 n1685 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3752 (n3762 n3763 n3754 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3745 (n3756 n3757 n3755 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1686 (n1728 n1729 n1727 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1671 (n1712 n1713 n1680 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1693 (n1734 n1735 n1726 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1680 (n1723 n1722 n1714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1684 (n7454 n126 n1722 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1673 (n1716 n1717 n1715 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3911 (n3919 n3918 n3910 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3915 (n7452 n62 n3918 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3904 (n3912 n3913 n3911 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3902 (n3908 n3909 n3876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3871 (n3878 n3879 n3877 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3924 (n3930 n3931 n3922 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3917 (n3924 n3925 n3923 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3979 (n7383 n127 n3981 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3968 (n3975 n3976 n3974 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3975 (n3981 n3982 n3973 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3935 (n3941 n3942 n3940 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3959 (n3965 n3966 n3957 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3966 (n3971 n3972 n3939 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3988 (n3993 n3994 n3985 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3981 (n3987 n3988 n3986 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2695 (n2721 n2722 n2713 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2699 (n7419 n9367 n2721 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2688 (n2715 n2716 n2714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2686 (n2711 n2712 n2679 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2655 (n2681 n2682 n2680 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2708 (n2733 n2734 n2725 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2701 (n2727 n2728 n2726 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2679 (n2705 n2706 n2697 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2672 (n2699 n2700 n2698 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U576 (n635 n636 n627 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2871 (n2894 n2895 n2886 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U768 (n824 n825 n816 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2864 (n2888 n2889 n2887 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2847 (n2870 n2871 n2869 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2856 (n2880 n2881 n2872 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2849 (n2874 n2875 n2873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2878 (n2900 n2901 n2868 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2900 (n2922 n2923 n2914 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2913 (n2937 n2938 n2936 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3028 (n3048 n3049 n3040 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3021 (n3042 n3043 n3041 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3006 (n3026 n3027 n2994 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2975 (n2996 n2997 n2995 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3019 (n7416 n9365 n3036 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3015 (n3037 n3036 n3028 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3008 (n3030 n3031 n3029 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2999 (n3020 n3021 n3012 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2992 (n3014 n3015 n3013 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U896 (n950 n951 n942 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U953 (n1007 n1008 n1006 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U960 (n1013 n1014 n1005 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U938 (n993 n994 n992 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U936 (n989 n990 n988 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U945 (n999 n1000 n991 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U967 (n1019 n1020 n987 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U989 (n1041 n1042 n1033 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U982 (n1035 n1036 n1034 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U976 (n1029 n1030 n1021 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U980 (n7415 n7372 n1029 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U969 (n1023 n1024 n1022 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3156 (n3174 n3175 n3166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3149 (n3168 n3169 n3167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3134 (n3152 n3153 n3120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3103 (n3122 n3123 n3121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3143 (n3162 n3163 n3154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3147 (n7385 n10016 n3162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3136 (n3156 n3157 n3155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3127 (n3146 n3147 n3138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3120 (n3140 n3141 n3139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1024 (n1076 n1077 n1068 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1081 (n1133 n1134 n1132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1088 (n1139 n1140 n1131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1066 (n1119 n1120 n1118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1064 (n1115 n1116 n1114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1073 (n1125 n1126 n1117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1095 (n1145 n1146 n1113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1117 (n1167 n1168 n1159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1110 (n1161 n1162 n1160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1104 (n1156 n1155 n1147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1108 (n126 n7384 n1155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1097 (n1149 n1150 n1148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3284 (n3300 n3301 n3292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3277 (n3294 n3295 n3293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3262 (n3278 n3279 n3246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3271 (n3289 n3288 n3280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3275 (n7437 n10016 n3288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3264 (n3282 n3283 n3281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3255 (n3272 n3273 n3264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3231 (n3248 n3249 n3247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3297 (n3315 n3316 n3314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2657 (n2685 n2686 n2684 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2664 (n2691 n2692 n2683 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2529 (n2559 n2560 n2558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2536 (n2565 n2566 n2557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2527 (n2555 n2556 n2554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2551 (n2579 n2580 n2571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2544 (n2573 n2574 n2572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3383 (n3398 n3399 n3390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1280 (n1328 n1329 n1320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3376 (n3392 n3393 n3391 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3359 (n3374 n3375 n3373 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3368 (n3384 n3385 n3376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3361 (n3378 n3379 n3377 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1465 (n1511 n1512 n1510 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1457 (n1503 n1504 n1495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3681 (n3693 n3694 n3692 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3688 (n3699 n3700 n3691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1585 (n1629 n1630 n1621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1578 (n1623 n1624 n1622 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1576 (n1619 n1620 n1618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1600 (n1643 n1644 n1635 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1593 (n1637 n1638 n1636 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1812 (n7452 n10110 n1848 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1801 (n1842 n1843 n1841 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1808 (n1849 n1848 n1840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1768 (n1808 n1809 n1807 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1777 (n1818 n1819 n1810 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1799 (n1838 n1839 n1806 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1821 (n1860 n1861 n1852 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1814 (n1854 n1855 n1853 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1792 (n1832 n1833 n1824 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1785 (n1826 n1827 n1825 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3895 (n3902 n3903 n3894 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3888 (n3896 n3897 n3895 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1878 (n1917 n1918 n1916 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1885 (n1923 n1924 n1915 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1865 (n1905 n1906 n1904 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1832 (n1871 n1872 n1870 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1841 (n1881 n1882 n1873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1863 (n1901 n1902 n1869 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1876 (n7371 n7383 n1911 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1872 (n1911 n1912 n1903 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1856 (n1895 n1896 n1887 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1849 (n1889 n1890 n1888 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3952 (n3959 n3960 n3958 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4109 (n4113 n4114 n4112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4116 (n4119 n4120 n4111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4094 (n4097 n4098 n4065 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4103 (n4108 n4107 n4099 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4107 (n7450 n9020 n4107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4096 (n4101 n4102 n4100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4087 (n4091 n4092 n4083 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4063 (n4067 n4068 n4066 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4136 (n4140 n4141 n4132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4129 (n4134 n4135 n4133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4127 (n4130 n4131 n4129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4151 (n4154 n4155 n4146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4144 (n4148 n4149 n4147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4158 (n4160 n4161 n4128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4180 (n4182 n4183 n4174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2516 (n2544 n2545 n2536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2509 (n2538 n2539 n2537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2463 (n2492 n2493 n2491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2487 (n2516 n2517 n2508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2494 (n2522 n2523 n2490 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2503 (n2532 n2533 n2524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2507 (n7470 n9367 n2532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2496 (n2526 n2527 n2525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U448 (n509 n510 n501 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U441 (n503 n504 n502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U424 (n485 n486 n484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U455 (n515 n516 n483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U433 (n495 n496 n487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U426 (n489 n490 n488 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U477 (n537 n538 n529 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U470 (n531 n532 n530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U464 (n526 n525 n517 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U468 (n7402 n9364 n525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U457 (n519 n520 n518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2567 (n2596 n2595 n2587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2571 (n7402 n10015 n2595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2560 (n2589 n2590 n2588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2772 (n2796 n2797 n2788 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2765 (n2790 n2791 n2789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2719 (n2744 n2745 n2743 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2728 (n2754 n2755 n2746 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2750 (n2774 n2775 n2742 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2763 (n7418 n46 n2784 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2759 (n2784 n2785 n2776 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2752 (n2778 n2779 n2777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2743 (n2768 n2769 n2760 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2736 (n2762 n2763 n2761 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U761 (n818 n819 n817 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U746 (n804 n805 n803 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U744 (n800 n801 n799 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U753 (n810 n811 n802 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U775 (n830 n831 n798 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U797 (n852 n853 n844 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U790 (n846 n847 n845 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2893 (n2916 n2917 n2915 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U784 (n840 n841 n832 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U788 (n7386 n128 n840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U777 (n834 n835 n833 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2891 (n7386 n9018 n2910 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2887 (n2910 n2911 n2902 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2880 (n2904 n2905 n2903 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3520 (n3534 n3535 n3533 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3527 (n3540 n3541 n3532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4303 (read_register_1\<0\> n10016 n4272 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U3531 (n7469 n62 n3540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3648 (n3660 n3661 n3659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4160 (n4164 n4165 n4163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4167 (n4171 n4170 n4162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4282 (n41 n44 n4261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4251 (n4242 n7539 n2265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4257 (n4206 n7539 n2269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4299 (n4272 n9 n2206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3079 (n3100 n3099 n3091 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3072 (n3093 n3094 n3092 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3083 (n7415 n9018 n3099 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2816 (n2841 n2842 n2840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2823 (n2847 n2848 n2839 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2827 (n7400 n9019 n2847 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3207 (n3225 n3226 n3217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3211 (n7384 n9019 n3225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3200 (n3219 n3220 n3218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3198 (n3215 n3216 n3183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3220 (n3237 n3238 n3229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3213 (n3231 n3232 n3230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4171 (n7461 n9019 n4170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1168 (n1218 n1219 n1210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1172 (n7437 n7369 n1218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1161 (n1212 n1213 n1211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1159 (n1208 n1209 n1176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1128 (n1178 n1179 n1177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1181 (n1230 n1231 n1222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1174 (n1224 n1225 n1223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1152 (n1202 n1203 n1194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1145 (n1196 n1197 n1195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3248 (n3266 n3267 n3265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2224 (n2236 n2237 n2235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2231 (n2246 n2247 n2234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2207 (n2210 n2211 n2209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2216 (n2224 n2225 n2212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2209 (n2214 n2215 n2213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2465 (n2496 n2497 n2495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3240 (n3258 n3259 n3250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2472 (n2502 n2503 n2494 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3661 (n3672 n3673 n3671 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3668 (n3678 n3679 n3670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3655 (n3667 n3666 n3658 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3659 (n7432 n9366 n3666 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3615 (n3626 n3627 n3625 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3646 (n3656 n3657 n3624 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3639 (n3650 n3651 n3642 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3632 (n3644 n3645 n3643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3624 (n3636 n3637 n3628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3617 (n3630 n3631 n3629 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3696 (n3707 n3708 n3706 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4023 (n4028 n4029 n4020 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4016 (n4022 n4023 n4021 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4030 (n4034 n4035 n4002 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4052 (n4056 n4057 n4048 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3999 (n4004 n4005 n4003 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4008 (n4014 n4015 n4006 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4001 (n4008 n4009 n4007 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4229 (n10215 n8274 n2245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2041 (n2078 n2079 n2077 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2048 (n2084 n2085 n2076 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2024 (n2060 n2061 n2059 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2055 (n2090 n2091 n2058 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2033 (n2070 n2071 n2062 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2026 (n2064 n2065 n2063 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2077 (n2112 n2113 n2104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2070 (n2106 n2107 n2105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4173 (n4176 n4177 n4175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2064 (n2100 n2101 n2092 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2068 (n7461 n7471 n2100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2057 (n2094 n2095 n2093 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U413 (n474 n475 n466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U406 (n468 n469 n467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U391 (n452 n453 n420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U360 (n422 n423 n421 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U400 (n463 n462 n454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U404 (n7470 n7370 n462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U393 (n456 n457 n455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U384 (n446 n447 n438 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U377 (n440 n441 n439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2480 (n2510 n2511 n2509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1913 (n1952 n1953 n1951 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1920 (n1958 n1959 n1950 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1896 (n1934 n1935 n1933 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1927 (n1964 n1965 n1932 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1905 (n1944 n1945 n1936 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1898 (n1938 n1939 n1937 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1949 (n1986 n1987 n1978 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1942 (n1980 n1981 n1979 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4045 (n4050 n4051 n4049 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1940 (n7451 n7370 n1974 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4043 (n7451 n9366 n4044 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4039 (n4045 n4044 n4036 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1936 (n1975 n1974 n1966 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1000 (n1052 n1053 n1051 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1009 (n1062 n1063 n1054 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1017 (n1070 n1071 n1069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3112 (n3132 n3133 n3124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3105 (n3126 n3127 n3125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3809 (n3819 n3820 n3818 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3816 (n3825 n3826 n3817 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3807 (n3815 n3816 n3814 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3831 (n3839 n3840 n3831 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U128 (n175 n176 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U121 (n165 n166 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n143 n144 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U135 (n185 n186 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U157 (n218 n219 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U104 (n139 n140 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (n153 n154 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2260 (n2289 n2290 n2277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2253 (n2279 n2280 n2278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2238 (n2256 n2257 n2208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2247 (n2270 n2271 n2258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2251 (n7460 n7556 n2270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2240 (n2260 n2261 n2259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1748 (n7453 n7471 n1785 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1744 (n1786 n1785 n1777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2155 (n2176 n2175 n2165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2143 (n2167 n2168 n2166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2163 (n7399 n7370 n2175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U583 (n641 n642 n609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U585 (n645 n646 n644 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U596 (n7419 n10110 n651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U592 (n652 n651 n643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U605 (n663 n664 n655 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U598 (n657 n658 n656 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U552 (n611 n612 n610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U569 (n629 n630 n628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U561 (n621 n622 n613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U554 (n615 n616 n614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U362 (n426 n427 n425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U369 (n432 n433 n424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U633 (n692 n693 n691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U640 (n698 n699 n690 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U616 (n674 n675 n673 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U625 (n684 n685 n676 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U618 (n678 n679 n677 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U647 (n704 n705 n672 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U662 (n720 n721 n719 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U669 (n726 n727 n718 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U656 (n715 n714 n706 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U660 (n7418 n129 n714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U649 (n708 n709 n707 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1329 (n1377 n1378 n1369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U881 (n936 n937 n928 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3425 (n3441 n3442 n3440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3432 (n3447 n3448 n3439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1322 (n1371 n1372 n1370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U874 (n930 n931 n929 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U889 (n944 n945 n943 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1337 (n1385 n1386 n1384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U872 (n926 n927 n925 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1320 (n1367 n1368 n1366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2631 (n2659 n2658 n2650 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2635 (n7401 n9365 n2658 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2624 (n2652 n2653 n2651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2622 (n2648 n2649 n2616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2591 (n2618 n2619 n2617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4255 (n4241 n10215 n2268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2644 (n2670 n2671 n2662 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2637 (n2664 n2665 n2663 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2615 (n2642 n2643 n2634 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2608 (n2636 n2637 n2635 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2600 (n2628 n2629 n2620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2593 (n2622 n2623 n2621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1529 (n1574 n1575 n1573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1536 (n1580 n1581 n1572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1512 (n1556 n1557 n1555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1521 (n1566 n1567 n1558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1514 (n1560 n1561 n1559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1543 (n1586 n1587 n1554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1565 (n1608 n1609 n1600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1558 (n1602 n1603 n1601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1552 (n1597 n1596 n1588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1556 (n7432 n10111 n1596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1545 (n1590 n1591 n1589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4032 (n4038 n4039 n4037 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3847 (n3855 n3856 n3847 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3840 (n3849 n3850 n3848 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3851 (n7453 n9366 n3855 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3838 (n3845 n3846 n3813 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3860 (n3867 n3868 n3859 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3853 (n3861 n3862 n3860 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1360 (n1408 n1407 n1399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1364 (n7434 n7372 n1407 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1353 (n1401 n1402 n1400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3392 (n3408 n3409 n3407 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1300 (n7435 n129 n1344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3403 (n7435 n7556 n3414 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3399 (n3414 n3415 n3406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3390 (n3404 n3405 n3372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3412 (n3426 n3427 n3418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3405 (n3420 n3421 n3419 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2439 (n2470 n2469 n2461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2443 (n7464 n7556 n2469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1929 (n1968 n1969 n1967 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2388 (n2418 n2419 n2410 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2381 (n2412 n2413 n2411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2366 (n2396 n2397 n2364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2335 (n2366 n2367 n2365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2375 (n2406 n2407 n2398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2379 (n7403 n46 n2406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2368 (n2400 n2401 n2399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2359 (n2390 n2391 n2382 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2352 (n2384 n2385 n2383 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3824 (n3833 n3834 n3832 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4289 (read_register_1\<4\> n60 n4268 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U3233 (n3252 n3253 n3251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2401 (n2433 n2434 n2432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2408 (n2439 n2440 n2431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2399 (n2429 n2430 n2428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2423 (n2453 n2454 n2445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2416 (n2447 n2448 n2446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4080 (n4085 n4086 n4084 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1273 (n1322 n1323 n1321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1256 (n1304 n1305 n1303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1265 (n1314 n1315 n1306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1258 (n1308 n1309 n1307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1287 (n1334 n1335 n1302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1309 (n1356 n1357 n1348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1302 (n1350 n1351 n1349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1296 (n1344 n1345 n1336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1289 (n1338 n1339 n1337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U720 (n778 n777 n769 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2200 (n9791 n7371 n2202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2196 (n2202 n59 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U724 (n7400 n7371 n777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U713 (n771 n772 n770 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1366 (n1413 n1414 n1412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2013 (n2049 n2050 n2041 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2006 (n2043 n2044 n2042 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1960 (n1997 n1998 n1996 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1984 (n2021 n2022 n2013 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1991 (n2027 n2028 n1995 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2000 (n2037 n2038 n2029 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2004 (n7450 n9364 n2037 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1993 (n2031 n2032 n2030 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3944 (n3951 n3952 n3943 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3937 (n3945 n3946 n3944 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2984 (n3006 n3007 n2998 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4072 (n4077 n4078 n4069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4065 (n4071 n4072 n4070 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4209 (n4211 n10216 n2229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4201 (n10215 n7611 n2222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3873 (n3882 n3883 n3881 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U3880 (n3888 n3889 n3880 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U912 (n966 n967 n958 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U916 (n7416 n10111 n966 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U340 (n7464 n10111 n399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U905 (n960 n961 n959 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U903 (n956 n957 n924 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U925 (n978 n979 n970 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U918 (n972 n973 n971 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U329 (n393 n394 n392 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U336 (n399 n400 n391 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2432 (n2463 n2464 n2462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2452 (n2481 n2482 n2473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2430 (n2459 n2460 n2427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2792 (n2817 n2818 n2809 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2785 (n2811 n2812 n2810 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2783 (n2807 n2808 n2806 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2800 (n2825 n2826 n2824 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2807 (n2831 n2832 n2823 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2814 (n2837 n2838 n2805 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2836 (n2859 n2860 n2851 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2829 (n2853 n2854 n2852 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4213 (n7574 n7611 n2232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4196 (n7570 n7612 n2218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4207 (n10216 n7612 n2228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2280 (n2313 n2314 n2305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2273 (n2307 n2308 n2306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2271 (n2303 n2304 n2302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2337 (n2370 n2371 n2369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2344 (n2376 n2377 n2368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4295 (n4215 n10212 n2297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4198 (n4202 n8280 n2219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4216 (n4215 n8280 n2233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2295 (n2327 n2328 n2319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1033 (n1086 n1087 n1085 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1044 (n7385 n9364 n1092 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1040 (n1092 n1093 n1084 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1031 (n1082 n1083 n1050 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1053 (n1104 n1105 n1096 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1046 (n1098 n1099 n1097 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U208 (n273 n274 n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U212 (n7404 n128 n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U201 (n267 n268 n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U199 (n263 n264 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U221 (n285 n286 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U214 (n279 n280 n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2324 (n2355 n2356 n2347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2317 (n2349 n2350 n2348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2302 (n2333 n2334 n2301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2311 (n2343 n2344 n2335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2304 (n2337 n2338 n2336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2315 (n7404 n9020 n2343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4306 (read_register_1\<4\> read_register_1\<3\> n4249 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U4305 (read_register_1\<1\> n7 n4266 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U4264 (n4250 n7539 n2275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4238 (n4222 n7574 n2254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4261 (n4241 n7574 n2274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4249 (n4241 n7570 n2264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2721 (n2748 n2749 n2747 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2977 (n3000 n3001 n2999 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U490 (n552 n553 n551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U497 (n558 n559 n550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U488 (n548 n549 n547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U512 (n572 n573 n564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2580 (n2607 n2608 n2599 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2573 (n2601 n2602 n2600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4273 (n4202 n10212 n2284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4203 (n4203 n7538 n2223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4296 (read_register_1\<4\> n10213 n4271 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U4280 (n10212 n7538 n2288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2445 (n2475 n2476 n2474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2558 (n2585 n2586 n2553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4278 (n10215 n8276 n2287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4227 (n10215 n7609 n2244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4292 (n4214 n8276 n2296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4241 (n4214 n8274 n2255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4271 (n8277 n7570 n2283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4286 (n10216 n8277 n2293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4233 (n10216 n7609 n2250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4224 (n4223 n7569 n2241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4235 (n10216 n8274 n2251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U4222 (n4222 n7569 n2240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U2288 (n2321 n2322 n2320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U185 (n251 n252 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1977 (n2015 n2016 n2014 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U249 (n314 n315 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U313 (n377 n378 n376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U320 (n383 n384 n375 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1002 (n1056 n1057 n1055 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U170 (n237 n238 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U177 (n243 n244 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U192 (n257 n258 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U168 (n233 n234 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n7460 n7369 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U272 (n336 n337 n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U276 (n7403 n7369 n336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (n189 n190 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U144 (n199 n200 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U265 (n330 n331 n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U263 (n326 n327 n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U285 (n348 n349 n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U278 (n342 n343 n341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U232 (n296 n297 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U256 (n320 n321 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U241 (n306 n307 n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U234 (n300 n301 n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U541 (n600 n601 n592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U534 (n594 n595 n593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U519 (n578 n579 n546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1737 (n1779 n1780 n1778 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1704 (n1745 n1746 n1744 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1713 (n1755 n1756 n1747 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1735 (n1775 n1776 n1743 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1757 (n1797 n1798 n1789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1750 (n1791 n1792 n1790 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1728 (n1769 n1770 n1761 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1721 (n1763 n1764 n1762 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U689 (n747 n748 n739 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U682 (n741 n742 n740 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U680 (n737 n738 n736 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U704 (n761 n762 n753 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U697 (n755 n756 n754 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U505 (n566 n567 n565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1706 (n1749 n1750 n1748 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1770 (n1812 n1813 n1811 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1450 (n1497 n1498 n1496 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1137 (n1188 n1189 n1180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1130 (n1182 n1183 n1181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1969 (n2007 n2008 n1999 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1962 (n2001 n2002 n2000 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1834 (n1875 n1876 n1874 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U150 (n208 n209 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1386 (n1434 n1435 n1433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U305 (n369 n370 n361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U296 (n359 n360 n358 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U327 (n389 n390 n357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U298 (n363 n364 n362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U733 (n789 n790 n781 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U342 (n405 n406 n404 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U349 (n411 n412 n403 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U726 (n783 n784 n782 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U711 (n767 n768 n735 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_register_file_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: control
// View name: schematic
subckt soc_no_opt_16may_control_schematic instruction\<31\> \
        instruction\<30\> instruction\<29\> instruction\<28\> \
        instruction\<27\> instruction\<26\> instruction\<25\> \
        instruction\<24\> instruction\<23\> instruction\<22\> \
        instruction\<21\> instruction\<20\> instruction\<19\> \
        instruction\<18\> instruction\<17\> instruction\<16\> \
        instruction\<15\> instruction\<14\> instruction\<13\> \
        instruction\<12\> instruction\<11\> instruction\<10\> \
        instruction\<9\> instruction\<8\> instruction\<7\> \
        instruction\<6\> instruction\<5\> instruction\<4\> \
        instruction\<3\> instruction\<2\> instruction\<1\> \
        instruction\<0\> wb_src\<1\> wb_src\<0\> wb_we mem_we mem_re \
        mem_write_width\<1\> mem_write_width\<0\> mem_load_unsigned \
        is_branch reg_or_PC is_jump inh_gnd inh_gnds inh_vdd inh_vdds
    U13 (instruction\<31\> n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n44 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n52 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n51 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n42 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n41 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n38 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n37 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (instruction\<6\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U74 (n29 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n20 wb_we inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U73 (n61 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (n55 mem_we inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n7 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (instruction\<2\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U72 (n63 is_branch inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (instruction\<4\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n6 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n30 mem_re inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (n60 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n22 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n18 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (instruction\<5\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U46 (n48 instruction\[13\] n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n31 n32 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n47 instruction\<30\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n49 n50 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n39 n40 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n35 n36 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n6 instruction\<5\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n25 n26 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n68 n27 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n18 n8 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n1 instruction\<4\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n57 n56 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (n30 n26 wb_src\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n58 n56 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n69 n59 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n56 n47 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (instruction\<6\> n64 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n69 instruction\<2\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (instruction\<1\> instruction\<0\> n60 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U47 (n6 n11 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U43 (n43 n10 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U44 (n46 n45 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U51 (instruction\<14\> n16 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U52 (instruction\<16\> instruction\<15\> n52 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U49 (instruction\<17\> n15 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U50 (instruction\<19\> instruction\<18\> n51 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U41 (instruction\<26\> n12 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U42 (instruction\<28\> instruction\<27\> n42 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U40 (instruction\[12\] n8 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U39 (instruction\<29\> n17 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U32 (n33 n34 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U36 (instruction\<20\> n14 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U37 (instruction\<22\> instruction\<21\> n38 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U34 (instruction\<23\> n13 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U35 (instruction\<24\> instruction\<25\> n37 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U28 (n28 n4 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U22 (n21 n70 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U23 (n23 n3 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U24 (n24 n2 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U25 (instruction\<5\> n8 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (n62 n2 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U62 (n29 n67 is_jump inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U53 (n53 n54 reg_or_PC inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U57 (n3 n1 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U59 (n22 instruction\<5\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U61 (instruction\<3\> instruction\<6\> n59 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U68 (instruction\<3\> n1 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (n8 n2 n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U66 (n60 n62 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    Thru3 (instruction\[12\] mem_write_width\<0\>) iprobe
    Thru1 (instruction\[13\] mem_write_width\<1\>) iprobe
    Thru0 (instruction\<14\> mem_load_unsigned) iprobe
    Thru4 (instruction\<12\> instruction\[12\]) iprobe
    Thru2 (instruction\<13\> instruction\[13\]) iprobe
    U7 (n70 wb_src\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
ends soc_no_opt_16may_control_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: imm_ext
// View name: schematic
subckt soc_no_opt_16may_imm_ext_schematic instr\<31\> instr\<30\> \
        instr\<29\> instr\<28\> instr\<27\> instr\<26\> instr\<25\> \
        instr\<24\> instr\<23\> instr\<22\> instr\<21\> instr\<20\> \
        instr\<19\> instr\<18\> instr\<17\> instr\<16\> instr\<15\> \
        instr\<14\> instr\<13\> instr\<12\> instr\<11\> instr\<10\> \
        instr\<9\> instr\<8\> instr\<7\> instr\<6\> instr\<5\> instr\<4\> \
        instr\<3\> instr\<2\> instr\<1\> instr\<0\> imm\<31\> imm\<30\> \
        imm\<29\> imm\<28\> imm\<27\> imm\<26\> imm\<25\> imm\<24\> \
        imm\<23\> imm\<22\> imm\<21\> imm\<20\> imm\<19\> imm\<18\> \
        imm\<17\> imm\<16\> imm\<15\> imm\<14\> imm\<13\> imm\<12\> \
        imm\<11\> imm\<10\> imm\<9\> imm\<8\> imm\<7\> imm\<6\> imm\<5\> \
        imm\<4\> imm\<3\> imm\<2\> imm\<1\> imm\<0\> is_imm inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U90 (n4 instr\<8\> n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n145 instr\<21\> n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n74 n75 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n77 instr\<31\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n78 n79 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n4 instr\<9\> n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n56 n55 imm\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (instr\<23\> n1 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n128 n129 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n135 n22 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n134 instr\<4\> n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n132 n133 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n4 instr\<7\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n21 n145 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n157 n120 imm\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (instr\<21\> n1 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n123 n124 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n23 n30 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n161 n118 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n115 n23 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (n109 n143 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (n159 n30 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n23 n29 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n28 n27 is_imm inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n109 n108 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n107 n108 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n105 n106 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n2 instr\<18\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n90 n9 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n152 n88 imm\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (instr\<17\> n7 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n17 instr\<31\> n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (instr\<30\> n17 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n113 n114 imm\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n21 n12 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (instr\<13\> n12 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n111 n9 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n147 n103 imm\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (instr\<12\> n7 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (instr\<14\> n1 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n9 n102 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n148 n100 imm\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (instr\<13\> n160 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (instr\<15\> n12 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n99 n9 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n149 n97 imm\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (instr\<14\> n160 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (instr\<16\> n12 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n96 n9 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n150 n94 imm\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (instr\<15\> n15 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (instr\<17\> n12 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n9 n93 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n151 n91 imm\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (instr\<16\> n15 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n87 n9 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n153 n84 imm\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (instr\<18\> n7 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (instr\<19\> n12 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n13 n26 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (instr\<6\> n141 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n118 n119 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n23 n53 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (instr\<1\> instr\<0\> n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (instr\<31\> n53 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n52 n11 imm\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n21 n7 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n69 n11 imm\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (instr\<12\> n1 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n112 n9 imm\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (instr\<19\> n160 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n11 n76 imm\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (instr\<21\> n160 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n11 n68 imm\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n160 instr\<22\> n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n11 n67 imm\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n18 n26 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n80 n23 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n161 n159 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (n143 n107 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n22 n109 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (instr\<2\> n163 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n155 n47 imm\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (instr\<24\> n12 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n4 instr\<10\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n4 instr\<11\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n145 instr\<23\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n145 instr\<24\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n49 n50 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n154 n42 imm\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (instr\<25\> n1 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n44 n45 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (instr\<26\> n12 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n40 n41 imm\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n17 instr\<25\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (instr\<26\> n17 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n38 n39 imm\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (instr\<27\> n12 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (instr\<29\> n12 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n34 n35 imm\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n17 instr\<28\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n17 instr\<27\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n36 n37 imm\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (instr\<28\> n1 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (instr\<29\> n17 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (instr\<30\> n1 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n31 n32 imm\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n15 instr\<23\> n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (n66 n11 imm\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n65 n11 imm\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n7 instr\<24\> n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n15 instr\<25\> n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n64 n11 imm\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (instr\<26\> n15 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n11 n63 imm\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (n7 instr\<27\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n62 n11 imm\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n7 instr\<28\> n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n61 n11 imm\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n15 instr\<29\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n60 n11 imm\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n15 instr\<30\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n11 n54 imm\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (n51 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n10 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U191 (n59 n158 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U194 (n127 n161 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U190 (n122 n157 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n46 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n3 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (instr\<12\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n33 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U195 (n142 n162 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U186 (n89 n152 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n8 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n86 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U181 (n110 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U182 (n101 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U183 (n98 n149 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U184 (n95 n150 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U185 (n92 n151 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U187 (n85 n153 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U192 (n117 n159 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n136 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U193 (n104 n160 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n82 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (instr\<20\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n20 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (instr\<6\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (instr\<3\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (instr\<5\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U196 (instr\<4\> n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U179 (instr\<22\> n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U178 (n58 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n23 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n73 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (instr\<2\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n73 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n73 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n160 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n25 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n25 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U189 (n48 n155 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U188 (n43 n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n71 n72 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U87 (n73 n146 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U95 (n80 n81 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U96 (n83 n24 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (n58 n146 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U63 (n57 n158 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U162 (instr\<6\> n6 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U160 (n139 n163 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U161 (instr\<6\> n19 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U159 (n138 n137 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U156 (instr\<2\> n13 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U158 (instr\<5\> n6 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U153 (n131 n130 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n125 n126 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U172 (n119 n24 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U138 (n116 n30 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (instr\<13\> n14 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (n83 n81 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U164 (n121 n19 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U163 (n140 n162 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U31 (n160 n2 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U169 (n144 n19 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U166 (n136 n13 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U145 (n121 n18 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U177 (instr\<4\> instr\<2\> n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U175 (n135 n13 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U127 (n22 n163 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (n70 imm\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx1_PB4_AFBB
ends soc_no_opt_16may_imm_ext_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: hazard_detector
// View name: schematic
subckt soc_no_opt_16may_hazard_detector_schematic ex_rd\<4\> ex_rd\<3\> \
        ex_rd\<2\> ex_rd\<1\> ex_rd\<0\> rs1\<4\> rs1\<3\> rs1\<2\> \
        rs1\<1\> rs1\<0\> rs2\<4\> rs2\<3\> rs2\<2\> rs2\<1\> rs2\<0\> \
        ex_wb_src\<1\> ex_wb_src\<0\> is_imm stall inh_gnd inh_gnds \
        inh_vdd inh_vdds
    U74 (n53 n71 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (rs2\<4\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U2 (rs2\<2\> n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (rs1\<3\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (rs1\<4\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n28 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (rs1\<2\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n4 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n16 n74 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n20 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (n10 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n23 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (rs1\<0\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U75 (ex_rd\<2\> n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U73 (rs2\<1\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U51 (ex_rd\<4\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U50 (ex_rd\<3\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U48 (ex_rd\<0\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U47 (rs1\<1\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (rs2\<3\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (n67 n66 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n61 n60 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U12 (n13 N2 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n70 n50 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (ex_rd\<1\> n50 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n52 n51 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n42 n41 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n36 n35 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (n17 N0 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U27 (ex_rd\<1\> n25 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n45 n25 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n27 n26 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U13 (n14 n15 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (n18 n19 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (n9 n11 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (n12 ex_wb_src\<1\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6 (n6 n7 stall inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7 (n8 ex_wb_src\<0\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U8 (n73 n9 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U52 (n46 rs2\<0\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n24 n46 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n57 n71 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n68 n69 N2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U69 (ex_rd\<3\> n4 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U68 (rs2\<3\> n48 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (n65 n64 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U66 (ex_rd\<4\> n22 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (rs2\<4\> n49 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U67 (n63 n62 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U62 (ex_rd\<2\> n2 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U61 (rs2\<2\> n72 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U63 (n59 n58 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U57 (n54 ex_rd\<1\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U58 (n54 n70 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U59 (n56 n55 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U42 (rs1\<3\> n48 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U43 (ex_rd\<3\> n1 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U44 (n40 n39 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U39 (rs1\<4\> n49 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U40 (ex_rd\<4\> n21 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U41 (n38 n37 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U34 (n32 n47 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U46 (n44 n43 N0 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U35 (rs1\<2\> n72 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U36 (ex_rd\<2\> n3 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U37 (n33 n34 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U31 (n29 ex_rd\<1\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U32 (n29 n45 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U33 (n30 n31 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U15 (rs2\<4\> n5 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U14 (rs2\<2\> n74 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U16 (rs2\<1\> rs2\<0\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U21 (rs1\<1\> n24 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U19 (rs1\<2\> n75 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U20 (rs1\<4\> rs1\<3\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U9 (n11 is_imm n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U56 (rs2\<0\> n46 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U30 (n46 n24 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_hazard_detector_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: instruction_decode
// View name: schematic
subckt soc_no_opt_16may_instruction_decode_schematic clk nreset \
        instr\<31\> instr\<30\> instr\<29\> instr\<28\> instr\<27\> \
        instr\<26\> instr\<25\> instr\<24\> instr\<23\> instr\<22\> \
        instr\<21\> instr\<20\> instr\<19\> instr\<18\> instr\<17\> \
        instr\<16\> instr\<15\> instr\<14\> instr\<13\> instr\<12\> \
        instr\<11\> instr\<10\> instr\<9\> instr\<8\> instr\<7\> \
        instr\<6\> instr\<5\> instr\<4\> instr\<3\> instr\<2\> instr\<1\> \
        instr\<0\> wb_reg\<4\> wb_reg\<3\> wb_reg\<2\> wb_reg\<1\> \
        wb_reg\<0\> wb_data\<31\> wb_data\<30\> wb_data\<29\> \
        wb_data\<28\> wb_data\<27\> wb_data\<26\> wb_data\<25\> \
        wb_data\<24\> wb_data\<23\> wb_data\<22\> wb_data\<21\> \
        wb_data\<20\> wb_data\<19\> wb_data\<18\> wb_data\<17\> \
        wb_data\<16\> wb_data\<15\> wb_data\<14\> wb_data\<13\> \
        wb_data\<12\> wb_data\<11\> wb_data\<10\> wb_data\<9\> \
        wb_data\<8\> wb_data\<7\> wb_data\<6\> wb_data\<5\> wb_data\<4\> \
        wb_data\<3\> wb_data\<2\> wb_data\<1\> wb_data\<0\> wb_write \
        reg1\<31\> reg1\<30\> reg1\<29\> reg1\<28\> reg1\<27\> reg1\<26\> \
        reg1\<25\> reg1\<24\> reg1\<23\> reg1\<22\> reg1\<21\> reg1\<20\> \
        reg1\<19\> reg1\<18\> reg1\<17\> reg1\<16\> reg1\<15\> reg1\<14\> \
        reg1\<13\> reg1\<12\> reg1\<11\> reg1\<10\> reg1\<9\> reg1\<8\> \
        reg1\<7\> reg1\<6\> reg1\<5\> reg1\<4\> reg1\<3\> reg1\<2\> \
        reg1\<1\> reg1\<0\> reg2\<31\> reg2\<30\> reg2\<29\> reg2\<28\> \
        reg2\<27\> reg2\<26\> reg2\<25\> reg2\<24\> reg2\<23\> reg2\<22\> \
        reg2\<21\> reg2\<20\> reg2\<19\> reg2\<18\> reg2\<17\> reg2\<16\> \
        reg2\<15\> reg2\<14\> reg2\<13\> reg2\<12\> reg2\<11\> reg2\<10\> \
        reg2\<9\> reg2\<8\> reg2\<7\> reg2\<6\> reg2\<5\> reg2\<4\> \
        reg2\<3\> reg2\<2\> reg2\<1\> reg2\<0\> imm\<31\> imm\<30\> \
        imm\<29\> imm\<28\> imm\<27\> imm\<26\> imm\<25\> imm\<24\> \
        imm\<23\> imm\<22\> imm\<21\> imm\<20\> imm\<19\> imm\<18\> \
        imm\<17\> imm\<16\> imm\<15\> imm\<14\> imm\<13\> imm\<12\> \
        imm\<11\> imm\<10\> imm\<9\> imm\<8\> imm\<7\> imm\<6\> imm\<5\> \
        imm\<4\> imm\<3\> imm\<2\> imm\<1\> imm\<0\> is_imm rs1\<4\> \
        rs1\<3\> rs1\<2\> rs1\<1\> rs1\<0\> rs2\<4\> rs2\<3\> rs2\<2\> \
        rs2\<1\> rs2\<0\> rd\<4\> rd\<3\> rd\<2\> rd\<1\> rd\<0\> \
        ex_rd\<4\> ex_rd\<3\> ex_rd\<2\> ex_rd\<1\> ex_rd\<0\> \
        ex_wb_src\<1\> ex_wb_src\<0\> stall mem_we mem_re mem_be\<1\> \
        mem_be\<0\> wb_src\<1\> wb_src\<0\> wb_we ALU_operation\<3\> \
        ALU_operation\<2\> ALU_operation\<1\> ALU_operation\<0\> is_branch \
        mem_load_unsigned reg_or_PC is_jump inh_gnd inh_gnds inh_vdd_rename \
        inh_vdds
    Vinstruction_decode (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    U77 (instr\<3\> n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U71 (n31 n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (n66 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n15 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n68 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n24 n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (instr\<5\> n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U72 (n49 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U73 (n26 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n14 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n12 rs1\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (instr\<17\> n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n7 rs1\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (instr\<16\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U74 (n45 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n58 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (instr\<2\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U58 (n58 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (n39 n70 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (instr\<14\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n62 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n73 n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U68 (instr\<13\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U2 (n63 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (instr\<12\> n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n65 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (instr\<18\> n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U59 (n57 n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n57 rs1\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n55 n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (instr\<6\> n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n55 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n9 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n9 rs2\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (instr\<21\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n48 n72 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U38 (n60 n40 ALU_operation\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U40 (n42 n41 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U27 (n30 n52 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U15 (n61 n60 ALU_operation\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U30 (instr\<2\> n62 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U28 (n33 n32 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U24 (n29 n25 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U23 (instr\<2\> n28 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U22 (n27 n2 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U18 (n20 n21 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U17 (n18 n19 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U21 (n25 instr\<14\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U20 (instr\<14\> n64 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U19 (n23 n22 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U52 (instr\<4\> n71 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U36 (n37 n38 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U37 (n63 n70 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U35 (n60 n36 ALU_operation\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U56 (instr\<3\> instr\<6\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U47 (instr\<3\> n59 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U33 (n35 n70 ALU_operation\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U43 (n45 n59 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U45 (n20 n62 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U32 (instr\<13\> n65 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U50 (n67 instr\<2\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n39 instr\<12\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n43 n44 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (instr\<13\> n37 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n66 n47 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n68 n53 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (n16 n17 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n24 n69 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n34 instr\<30\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n62 instr\<30\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n50 n56 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n51 instr\<4\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n46 n67 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n69 instr\<5\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n73 n6 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (instr\<1\> instr\<0\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n63 n65 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    Thru21 (instr\<7\> instr\[7\]) iprobe
    Thru19 (instr\<8\> instr\[8\]) iprobe
    Thru17 (instr\<9\> instr\[9\]) iprobe
    Thru15 (instr\<10\> instr\[10\]) iprobe
    Thru13 (instr\<11\> instr\[11\]) iprobe
    Thru11 (instr\<20\> instr\[20\]) iprobe
    Thru10 (instr\[20\] rs2\<0\>) iprobe
    Thru9 (instr\<22\> instr\[22\]) iprobe
    Thru8 (instr\[22\] rs2\<2\>) iprobe
    Thru7 (instr\<23\> instr\[23\]) iprobe
    Thru6 (instr\[23\] rs2\<3\>) iprobe
    Thru5 (instr\<24\> instr\[24\]) iprobe
    Thru4 (instr\[24\] rs2\<4\>) iprobe
    Thru3 (instr\<15\> instr\[15\]) iprobe
    Thru2 (instr\[15\] rs1\<0\>) iprobe
    Thru1 (instr\<19\> instr\[19\]) iprobe
    Thru0 (instr\[19\] rs1\<4\>) iprobe
    Thru20 (instr\[7\] rd\<0\>) iprobe
    Thru18 (instr\[8\] rd\<1\>) iprobe
    Thru16 (instr\[9\] rd\<2\>) iprobe
    Thru14 (instr\[10\] rd\<3\>) iprobe
    Thru12 (instr\[11\] rd\<4\>) iprobe
    register_file (clk nreset wb_write instr\[19\] n54 rs1\<2\> rs1\<1\> \
        instr\[15\] instr\[24\] instr\[23\] instr\[22\] n11 instr\[20\] \
        wb_reg\<4\> wb_reg\<3\> wb_reg\<2\> wb_reg\<1\> wb_reg\<0\> \
        wb_data\<31\> wb_data\<30\> wb_data\<29\> wb_data\<28\> \
        wb_data\<27\> wb_data\<26\> wb_data\<25\> wb_data\<24\> \
        wb_data\<23\> wb_data\<22\> wb_data\<21\> wb_data\<20\> \
        wb_data\<19\> wb_data\<18\> wb_data\<17\> wb_data\<16\> \
        wb_data\<15\> wb_data\<14\> wb_data\<13\> wb_data\<12\> \
        wb_data\<11\> wb_data\<10\> wb_data\<9\> wb_data\<8\> wb_data\<7\> \
        wb_data\<6\> wb_data\<5\> wb_data\<4\> wb_data\<3\> wb_data\<2\> \
        wb_data\<1\> wb_data\<0\> reg1\<31\> reg1\<30\> reg1\<29\> \
        reg1\<28\> reg1\<27\> reg1\<26\> reg1\<25\> reg1\<24\> reg1\<23\> \
        reg1\<22\> reg1\<21\> reg1\<20\> reg1\<19\> reg1\<18\> reg1\<17\> \
        reg1\<16\> reg1\<15\> reg1\<14\> reg1\<13\> reg1\<12\> reg1\<11\> \
        reg1\<10\> reg1\<9\> reg1\<8\> reg1\<7\> reg1\<6\> reg1\<5\> \
        reg1\<4\> reg1\<3\> reg1\<2\> reg1\<1\> reg1\<0\> reg2\<31\> \
        reg2\<30\> reg2\<29\> reg2\<28\> reg2\<27\> reg2\<26\> reg2\<25\> \
        reg2\<24\> reg2\<23\> reg2\<22\> reg2\<21\> reg2\<20\> reg2\<19\> \
        reg2\<18\> reg2\<17\> reg2\<16\> reg2\<15\> reg2\<14\> reg2\<13\> \
        reg2\<12\> reg2\<11\> reg2\<10\> reg2\<9\> reg2\<8\> reg2\<7\> \
        reg2\<6\> reg2\<5\> reg2\<4\> reg2\<3\> reg2\<2\> reg2\<1\> \
        reg2\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_register_file_schematic
    control (instr\<31\> instr\<30\> instr\<29\> instr\<28\> instr\<27\> \
        instr\<26\> instr\<25\> instr\[24\] instr\[23\] instr\[22\] \
        instr\<21\> instr\[20\] instr\[19\] instr\<18\> rs1\<2\> \
        instr\<16\> instr\[15\] n6 n1 n4 instr\[11\] instr\[10\] \
        instr\[9\] instr\[8\] instr\[7\] n3 instr\<5\> instr\<4\> \
        instr\<3\> instr\<2\> instr\<1\> instr\<0\> wb_src\<1\> \
        wb_src\<0\> wb_we mem_we mem_re mem_be\<1\> mem_be\<0\> \
        mem_load_unsigned is_branch reg_or_PC is_jump inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_control_schematic
    immediate_extender (instr\<31\> instr\<30\> instr\<29\> instr\<28\> \
        instr\<27\> instr\<26\> instr\<25\> instr\[24\] instr\[23\] \
        instr\[22\] rs2\<1\> instr\[20\] instr\[19\] n54 instr\<17\> \
        rs1\<1\> instr\[15\] n6 n1 n4 instr\[11\] instr\[10\] instr\[9\] \
        instr\[8\] instr\[7\] n56 instr\<5\> instr\<4\> instr\<3\> n53 \
        instr\<1\> instr\<0\> imm\<31\> imm\<30\> imm\<29\> imm\<28\> \
        imm\<27\> imm\<26\> imm\<25\> imm\<24\> imm\<23\> imm\<22\> \
        imm\<21\> imm\<20\> imm\<19\> imm\<18\> imm\<17\> imm\<16\> \
        imm\<15\> imm\<14\> imm\<13\> imm\<12\> imm\<11\> imm\<10\> \
        imm\<9\> imm\<8\> imm\<7\> imm\<6\> imm\<5\> imm\<4\> imm\<3\> \
        imm\<2\> imm\<1\> imm\<0\> is_imm inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_imm_ext_schematic
    hazard_detector (ex_rd\<4\> ex_rd\<3\> ex_rd\<2\> ex_rd\<1\> \
        ex_rd\<0\> instr\[19\] rs1\<3\> rs1\<2\> instr\<16\> instr\[15\] \
        instr\[24\] instr\[23\] instr\[22\] rs2\<1\> instr\[20\] \
        ex_wb_src\<1\> ex_wb_src\<0\> is_imm stall inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_hazard_detector_schematic
ends soc_no_opt_16may_instruction_decode_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: top
// View name: schematic
subckt soc_no_opt_16may_top_schematic clk nreset sleep pass fail \
        data_memory_address\<11\> data_memory_address\<10\> \
        data_memory_address\<9\> data_memory_address\<8\> \
        data_memory_address\<7\> data_memory_address\<6\> \
        data_memory_address\<5\> data_memory_address\<4\> \
        data_memory_address\<3\> data_memory_address\<2\> \
        data_memory_address\<1\> data_memory_address\<0\> \
        data_memory_read_data\<31\> data_memory_read_data\<30\> \
        data_memory_read_data\<29\> data_memory_read_data\<28\> \
        data_memory_read_data\<27\> data_memory_read_data\<26\> \
        data_memory_read_data\<25\> data_memory_read_data\<24\> \
        data_memory_read_data\<23\> data_memory_read_data\<22\> \
        data_memory_read_data\<21\> data_memory_read_data\<20\> \
        data_memory_read_data\<19\> data_memory_read_data\<18\> \
        data_memory_read_data\<17\> data_memory_read_data\<16\> \
        data_memory_read_data\<15\> data_memory_read_data\<14\> \
        data_memory_read_data\<13\> data_memory_read_data\<12\> \
        data_memory_read_data\<11\> data_memory_read_data\<10\> \
        data_memory_read_data\<9\> data_memory_read_data\<8\> \
        data_memory_read_data\<7\> data_memory_read_data\<6\> \
        data_memory_read_data\<5\> data_memory_read_data\<4\> \
        data_memory_read_data\<3\> data_memory_read_data\<2\> \
        data_memory_read_data\<1\> data_memory_read_data\<0\> \
        data_memory_be\<1\> data_memory_be\<0\> \
        data_memory_write_data\<31\> data_memory_write_data\<30\> \
        data_memory_write_data\<29\> data_memory_write_data\<28\> \
        data_memory_write_data\<27\> data_memory_write_data\<26\> \
        data_memory_write_data\<25\> data_memory_write_data\<24\> \
        data_memory_write_data\<23\> data_memory_write_data\<22\> \
        data_memory_write_data\<21\> data_memory_write_data\<20\> \
        data_memory_write_data\<19\> data_memory_write_data\<18\> \
        data_memory_write_data\<17\> data_memory_write_data\<16\> \
        data_memory_write_data\<15\> data_memory_write_data\<14\> \
        data_memory_write_data\<13\> data_memory_write_data\<12\> \
        data_memory_write_data\<11\> data_memory_write_data\<10\> \
        data_memory_write_data\<9\> data_memory_write_data\<8\> \
        data_memory_write_data\<7\> data_memory_write_data\<6\> \
        data_memory_write_data\<5\> data_memory_write_data\<4\> \
        data_memory_write_data\<3\> data_memory_write_data\<2\> \
        data_memory_write_data\<1\> data_memory_write_data\<0\> \
        data_memory_write_enable data_memory_read_enable \
        inst_memory_address\<10\> inst_memory_address\<9\> \
        inst_memory_address\<8\> inst_memory_address\<7\> \
        inst_memory_address\<6\> inst_memory_address\<5\> \
        inst_memory_address\<4\> inst_memory_address\<3\> \
        inst_memory_address\<2\> inst_memory_address\<1\> \
        inst_memory_address\<0\> inst_memory_read_data\<31\> \
        inst_memory_read_data\<30\> inst_memory_read_data\<29\> \
        inst_memory_read_data\<28\> inst_memory_read_data\<27\> \
        inst_memory_read_data\<26\> inst_memory_read_data\<25\> \
        inst_memory_read_data\<24\> inst_memory_read_data\<23\> \
        inst_memory_read_data\<22\> inst_memory_read_data\<21\> \
        inst_memory_read_data\<20\> inst_memory_read_data\<19\> \
        inst_memory_read_data\<18\> inst_memory_read_data\<17\> \
        inst_memory_read_data\<16\> inst_memory_read_data\<15\> \
        inst_memory_read_data\<14\> inst_memory_read_data\<13\> \
        inst_memory_read_data\<12\> inst_memory_read_data\<11\> \
        inst_memory_read_data\<10\> inst_memory_read_data\<9\> \
        inst_memory_read_data\<8\> inst_memory_read_data\<7\> \
        inst_memory_read_data\<6\> inst_memory_read_data\<5\> \
        inst_memory_read_data\<4\> inst_memory_read_data\<3\> \
        inst_memory_read_data\<2\> inst_memory_read_data\<1\> \
        inst_memory_read_data\<0\> inst_memory_write_enable inh_gnd \
        inh_gnds inh_vdd_rename inh_vdds
    Vtop (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    U32 (n30 n31 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U49 (n47 n48 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U44 (n43 n44 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U41 (instruction_IFID\<24\> n56 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U42 (instruction_IFID\<26\> instruction_IFID\<3\> n39 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U39 (instruction_IFID\<5\> n62 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U40 (instruction_IFID\<8\> instruction_IFID\<7\> n38 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U36 (instruction_IFID\<10\> n59 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U37 (instruction_IFID\<19\> instruction_IFID\<17\> n35 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U34 (instruction_IFID\<1\> n57 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U35 (instruction_IFID\<23\> instruction_IFID\<21\> n34 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U30 (n21 instruction_IFID\<13\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U22 (n21 instruction_IFID\<18\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U28 (instruction_IFID\<14\> n54 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U29 (instruction_IFID\<29\> instruction_IFID\<30\> n28 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U23 (n22 n58 pass inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U24 (n24 n25 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U20 (instruction_IFID\<22\> n63 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U21 (instruction_IFID\<2\> instruction_IFID\<6\> n20 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U15 (n14 n53 fail inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U16 (n16 n17 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U53 (instruction_IFID\<16\> instruction_IFID\<15\> n50 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U52 (instruction_IFID\<20\> n60 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (instruction_IFID\<12\> n61 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (instruction_IFID\<11\> instruction_IFID\<0\> n49 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U43 (n41 n42 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n51 n29 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n52 instruction_IFID\<9\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (instruction_IFID\<4\> instruction_IFID\<31\> n46 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U45 (n55 instruction_IFID\<28\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (instruction_IFID\<27\> instruction_IFID\<25\> n45 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U38 (n36 n37 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n32 n33 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n26 n27 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (instruction_IFID\<2\> instruction_IFID\<6\> n24 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U25 (instruction_IFID\<18\> instruction_IFID\<22\> n25 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U19 (n18 n19 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (instruction_IFID\<29\> instruction_IFID\<30\> n16 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U17 (instruction_IFID\<13\> instruction_IFID\<14\> n17 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U13 (n11 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (nreset n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (n50 n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n49 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n40 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (n46 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (n45 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n39 n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n38 n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n35 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (n34 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (sleep n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n11 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (n28 n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n23 n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n20 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (n15 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (is_imm_ID n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U11 (rs1_ID\<0\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U10 (rs2_ID\<4\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (rs1_ID\<4\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U8 (rs1_ID\<2\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U5 (rs1_ID\<3\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U7 (rs2_ID\<2\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U6 (rs2_ID\<0\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    Thru0 (GND! inst_memory_write_enable) iprobe
    IDEX_pipeline_register (clk flush_IDEX ALU_operation_ID\<3\> \
        ALU_operation_ID\<2\> ALU_operation_ID\<1\> ALU_operation_ID\<0\> \
        ALU_operation_IDEX\<3\> ALU_operation_IDEX\<2\> \
        ALU_operation_IDEX\<1\> ALU_operation_IDEX\<0\> reg1_IDEX\<31\> \
        reg1_IDEX\<30\> reg1_IDEX\<29\> reg1_IDEX\<28\> reg1_IDEX\<27\> \
        reg1_IDEX\<26\> reg1_IDEX\<25\> reg1_IDEX\<24\> reg1_IDEX\<23\> \
        reg1_IDEX\<22\> reg1_IDEX\<21\> reg1_IDEX\<20\> reg1_IDEX\<19\> \
        reg1_IDEX\<18\> reg1_IDEX\<17\> reg1_IDEX\<16\> reg1_IDEX\<15\> \
        reg1_IDEX\<14\> reg1_IDEX\<13\> reg1_IDEX\<12\> reg1_IDEX\<11\> \
        reg1_IDEX\<10\> reg1_IDEX\<9\> reg1_IDEX\<8\> reg1_IDEX\<7\> \
        reg1_IDEX\<6\> reg1_IDEX\<5\> reg1_IDEX\<4\> reg1_IDEX\<3\> \
        reg1_IDEX\<2\> reg1_IDEX\<1\> reg1_IDEX\<0\> reg2_IDEX\<31\> \
        reg2_IDEX\<30\> reg2_IDEX\<29\> reg2_IDEX\<28\> reg2_IDEX\<27\> \
        reg2_IDEX\<26\> reg2_IDEX\<25\> reg2_IDEX\<24\> reg2_IDEX\<23\> \
        reg2_IDEX\<22\> reg2_IDEX\<21\> reg2_IDEX\<20\> reg2_IDEX\<19\> \
        reg2_IDEX\<18\> reg2_IDEX\<17\> reg2_IDEX\<16\> reg2_IDEX\<15\> \
        reg2_IDEX\<14\> reg2_IDEX\<13\> reg2_IDEX\<12\> reg2_IDEX\<11\> \
        reg2_IDEX\<10\> reg2_IDEX\<9\> reg2_IDEX\<8\> reg2_IDEX\<7\> \
        reg2_IDEX\<6\> reg2_IDEX\<5\> reg2_IDEX\<4\> reg2_IDEX\<3\> \
        reg2_IDEX\<2\> reg2_IDEX\<1\> reg2_IDEX\<0\> imm_IDEX\<31\> \
        imm_IDEX\<30\> imm_IDEX\<29\> imm_IDEX\<28\> imm_IDEX\<27\> \
        imm_IDEX\<26\> imm_IDEX\<25\> imm_IDEX\<24\> imm_IDEX\<23\> \
        imm_IDEX\<22\> imm_IDEX\<21\> imm_IDEX\<20\> imm_IDEX\<19\> \
        imm_IDEX\<18\> imm_IDEX\<17\> imm_IDEX\<16\> imm_IDEX\<15\> \
        imm_IDEX\<14\> imm_IDEX\<13\> imm_IDEX\<12\> imm_IDEX\<11\> \
        imm_IDEX\<10\> imm_IDEX\<9\> imm_IDEX\<8\> imm_IDEX\<7\> \
        imm_IDEX\<6\> imm_IDEX\<5\> imm_IDEX\<4\> imm_IDEX\<3\> \
        imm_IDEX\<2\> imm_IDEX\<1\> imm_IDEX\<0\> is_imm_IDEX \
        rs1_IDEX\<4\> rs1_IDEX\<3\> rs1_IDEX\<2\> rs1_IDEX\<1\> \
        rs1_IDEX\<0\> rs2_IDEX\<4\> rs2_IDEX\<3\> rs2_IDEX\<2\> \
        rs2_IDEX\<1\> rs2_IDEX\<0\> rd_IDEX\<4\> rd_IDEX\<3\> rd_IDEX\<2\> \
        rd_IDEX\<1\> rd_IDEX\<0\> reg1_ID\<31\> reg1_ID\<30\> \
        reg1_ID\<29\> reg1_ID\<28\> reg1_ID\<27\> reg1_ID\<26\> \
        reg1_ID\<25\> reg1_ID\<24\> reg1_ID\<23\> reg1_ID\<22\> \
        reg1_ID\<21\> reg1_ID\<20\> reg1_ID\<19\> reg1_ID\<18\> \
        reg1_ID\<17\> reg1_ID\<16\> reg1_ID\<15\> reg1_ID\<14\> \
        reg1_ID\<13\> reg1_ID\<12\> reg1_ID\<11\> reg1_ID\<10\> \
        reg1_ID\<9\> reg1_ID\<8\> reg1_ID\<7\> reg1_ID\<6\> reg1_ID\<5\> \
        reg1_ID\<4\> reg1_ID\<3\> reg1_ID\<2\> reg1_ID\<1\> reg1_ID\<0\> \
        reg2_ID\<31\> reg2_ID\<30\> reg2_ID\<29\> reg2_ID\<28\> \
        reg2_ID\<27\> reg2_ID\<26\> reg2_ID\<25\> reg2_ID\<24\> \
        reg2_ID\<23\> reg2_ID\<22\> reg2_ID\<21\> reg2_ID\<20\> \
        reg2_ID\<19\> reg2_ID\<18\> reg2_ID\<17\> reg2_ID\<16\> \
        reg2_ID\<15\> reg2_ID\<14\> reg2_ID\<13\> reg2_ID\<12\> \
        reg2_ID\<11\> reg2_ID\<10\> reg2_ID\<9\> reg2_ID\<8\> reg2_ID\<7\> \
        reg2_ID\<6\> reg2_ID\<5\> reg2_ID\<4\> reg2_ID\<3\> reg2_ID\<2\> \
        reg2_ID\<1\> reg2_ID\<0\> imm_ID\<31\> imm_ID\<30\> imm_ID\<29\> \
        imm_ID\<28\> imm_ID\<27\> imm_ID\<26\> imm_ID\<25\> imm_ID\<24\> \
        imm_ID\<23\> imm_ID\<22\> imm_ID\<21\> imm_ID\<20\> imm_ID\<19\> \
        imm_ID\<18\> imm_ID\<17\> imm_ID\<16\> imm_ID\<15\> imm_ID\<14\> \
        imm_ID\<13\> imm_ID\<12\> imm_ID\<11\> imm_ID\<10\> imm_ID\<9\> \
        imm_ID\<8\> imm_ID\<7\> imm_ID\<6\> imm_ID\<5\> imm_ID\<4\> \
        imm_ID\<3\> imm_ID\<2\> imm_ID\<1\> imm_ID\<0\> n3 n8 n4 n7 \
        rs1_ID\<1\> n10 n9 rs2_ID\<3\> n6 rs2_ID\<1\> n5 rd_ID\<4\> \
        rd_ID\<3\> rd_ID\<2\> rd_ID\<1\> rd_ID\<0\> mem_we_ID mem_re_ID \
        mem_be_ID\<1\> mem_be_ID\<0\> mem_load_unsigned_ID \
        mem_load_unsigned_IDEX wb_src_ID\<1\> wb_src_ID\<0\> wb_we_ID \
        mem_we_IDEX mem_re_IDEX mem_be_IDEX\<1\> mem_be_IDEX\<0\> \
        wb_src_IDEX\<1\> wb_src_IDEX\<0\> wb_we_IDEX is_branch_ID \
        is_branch_IDEX branch_target_IFID\<10\> branch_target_IFID\<9\> \
        branch_target_IFID\<8\> branch_target_IFID\<7\> \
        branch_target_IFID\<6\> branch_target_IFID\<5\> \
        branch_target_IFID\<4\> branch_target_IFID\<3\> \
        branch_target_IFID\<2\> branch_target_IFID\<1\> \
        branch_target_IFID\<0\> branch_target_IDEX\<10\> \
        branch_target_IDEX\<9\> branch_target_IDEX\<8\> \
        branch_target_IDEX\<7\> branch_target_IDEX\<6\> \
        branch_target_IDEX\<5\> branch_target_IDEX\<4\> \
        branch_target_IDEX\<3\> branch_target_IDEX\<2\> \
        branch_target_IDEX\<1\> branch_target_IDEX\<0\> \
        current_PC_IFID\<10\> current_PC_IFID\<9\> current_PC_IFID\<8\> \
        current_PC_IFID\<7\> current_PC_IFID\<6\> current_PC_IFID\<5\> \
        current_PC_IFID\<4\> current_PC_IFID\<3\> current_PC_IFID\<2\> \
        current_PC_IFID\<1\> current_PC_IFID\<0\> current_PC_IDEX\<10\> \
        current_PC_IDEX\<9\> current_PC_IDEX\<8\> current_PC_IDEX\<7\> \
        current_PC_IDEX\<6\> current_PC_IDEX\<5\> current_PC_IDEX\<4\> \
        current_PC_IDEX\<3\> current_PC_IDEX\<2\> current_PC_IDEX\<1\> \
        current_PC_IDEX\<0\> reg_or_PC_ID reg_or_PC_IDEX is_jump_ID \
        is_jump_IDEX PC_incr_IFID\<10\> PC_incr_IFID\<9\> \
        PC_incr_IFID\<8\> PC_incr_IFID\<7\> PC_incr_IFID\<6\> \
        PC_incr_IFID\<5\> PC_incr_IFID\<4\> PC_incr_IFID\<3\> \
        PC_incr_IFID\<2\> PC_incr_IFID\<1\> PC_incr_IFID\<0\> \
        PC_incr_IDEX\<10\> PC_incr_IDEX\<9\> PC_incr_IDEX\<8\> \
        PC_incr_IDEX\<7\> PC_incr_IDEX\<6\> PC_incr_IDEX\<5\> \
        PC_incr_IDEX\<4\> PC_incr_IDEX\<3\> PC_incr_IDEX\<2\> \
        PC_incr_IDEX\<1\> PC_incr_IDEX\<0\> branched_IFID branched_IDEX \
        inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_IDEX_preg_schematic
    instruction_fetch (clk n13 init_sleep n2 control_transfer_MEM \
        new_PC_MEM\<10\> new_PC_MEM\<9\> new_PC_MEM\<8\> new_PC_MEM\<7\> \
        new_PC_MEM\<6\> new_PC_MEM\<5\> new_PC_MEM\<4\> new_PC_MEM\<3\> \
        new_PC_MEM\<2\> new_PC_MEM\<1\> new_PC_MEM\<0\> stall_IF \
        instruction_IF\<31\> instruction_IF\<30\> instruction_IF\<29\> \
        instruction_IF\<28\> instruction_IF\<27\> instruction_IF\<26\> \
        instruction_IF\<25\> instruction_IF\<24\> instruction_IF\<23\> \
        instruction_IF\<22\> instruction_IF\<21\> instruction_IF\<20\> \
        instruction_IF\<19\> instruction_IF\<18\> instruction_IF\<17\> \
        instruction_IF\<16\> instruction_IF\<15\> instruction_IF\<14\> \
        instruction_IF\<13\> instruction_IF\<12\> instruction_IF\<11\> \
        instruction_IF\<10\> instruction_IF\<9\> instruction_IF\<8\> \
        instruction_IF\<7\> instruction_IF\<6\> instruction_IF\<5\> \
        instruction_IF\<4\> instruction_IF\<3\> instruction_IF\<2\> \
        instruction_IF\<1\> instruction_IF\<0\> branch_target_IF\<10\> \
        branch_target_IF\<9\> branch_target_IF\<8\> branch_target_IF\<7\> \
        branch_target_IF\<6\> branch_target_IF\<5\> branch_target_IF\<4\> \
        branch_target_IF\<3\> branch_target_IF\<2\> branch_target_IF\<1\> \
        branch_target_IF\<0\> current_PC_IF\<10\> current_PC_IF\<9\> \
        current_PC_IF\<8\> current_PC_IF\<7\> current_PC_IF\<6\> \
        current_PC_IF\<5\> current_PC_IF\<4\> current_PC_IF\<3\> \
        current_PC_IF\<2\> current_PC_IF\<1\> current_PC_IF\<0\> \
        branched_IF PC_incr_IF\<10\> PC_incr_IF\<9\> PC_incr_IF\<8\> \
        PC_incr_IF\<7\> PC_incr_IF\<6\> PC_incr_IF\<5\> PC_incr_IF\<4\> \
        PC_incr_IF\<3\> PC_incr_IF\<2\> PC_incr_IF\<1\> PC_incr_IF\<0\> \
        PC_incr_EXMEM\<10\> PC_incr_EXMEM\<9\> PC_incr_EXMEM\<8\> \
        PC_incr_EXMEM\<7\> PC_incr_EXMEM\<6\> PC_incr_EXMEM\<5\> \
        PC_incr_EXMEM\<4\> PC_incr_EXMEM\<3\> PC_incr_EXMEM\<2\> \
        PC_incr_EXMEM\<1\> PC_incr_EXMEM\<0\> branch_MEM is_branch_EXMEM \
        inst_memory_address\<10\> inst_memory_address\<9\> \
        inst_memory_address\<8\> inst_memory_address\<7\> \
        inst_memory_address\<6\> inst_memory_address\<5\> \
        inst_memory_address\<4\> inst_memory_address\<3\> \
        inst_memory_address\<2\> inst_memory_address\<1\> \
        inst_memory_address\<0\> inst_memory_read_data\<31\> \
        inst_memory_read_data\<30\> inst_memory_read_data\<29\> \
        inst_memory_read_data\<28\> inst_memory_read_data\<27\> \
        inst_memory_read_data\<26\> inst_memory_read_data\<25\> \
        inst_memory_read_data\<24\> inst_memory_read_data\<23\> \
        inst_memory_read_data\<22\> inst_memory_read_data\<21\> \
        inst_memory_read_data\<20\> inst_memory_read_data\<19\> \
        inst_memory_read_data\<18\> inst_memory_read_data\<17\> \
        inst_memory_read_data\<16\> inst_memory_read_data\<15\> \
        inst_memory_read_data\<14\> inst_memory_read_data\<13\> \
        inst_memory_read_data\<12\> inst_memory_read_data\<11\> \
        inst_memory_read_data\<10\> inst_memory_read_data\<9\> \
        inst_memory_read_data\<8\> inst_memory_read_data\<7\> \
        inst_memory_read_data\<6\> inst_memory_read_data\<5\> \
        inst_memory_read_data\<4\> inst_memory_read_data\<3\> \
        inst_memory_read_data\<2\> inst_memory_read_data\<1\> \
        inst_memory_read_data\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_instruction_fetch_schematic
    EXMEM_pipeline_register (clk flush_EXMEM ALU_result_EX\<31\> \
        ALU_result_EX\<30\> ALU_result_EX\<29\> ALU_result_EX\<28\> \
        ALU_result_EX\<27\> ALU_result_EX\<26\> ALU_result_EX\<25\> \
        ALU_result_EX\<24\> ALU_result_EX\<23\> ALU_result_EX\<22\> \
        ALU_result_EX\<21\> ALU_result_EX\<20\> ALU_result_EX\<19\> \
        ALU_result_EX\<18\> ALU_result_EX\<17\> ALU_result_EX\<16\> \
        ALU_result_EX\<15\> ALU_result_EX\<14\> ALU_result_EX\<13\> \
        ALU_result_EX\<12\> ALU_result_EX\<11\> ALU_result_EX\<10\> \
        ALU_result_EX\<9\> ALU_result_EX\<8\> ALU_result_EX\<7\> \
        ALU_result_EX\<6\> ALU_result_EX\<5\> ALU_result_EX\<4\> \
        ALU_result_EX\<3\> ALU_result_EX\<2\> ALU_result_EX\<1\> \
        ALU_result_EX\<0\> ALU_result_EXMEM\<31\> ALU_result_EXMEM\<30\> \
        ALU_result_EXMEM\<29\> ALU_result_EXMEM\<28\> \
        ALU_result_EXMEM\<27\> ALU_result_EXMEM\<26\> \
        ALU_result_EXMEM\<25\> ALU_result_EXMEM\<24\> \
        ALU_result_EXMEM\<23\> ALU_result_EXMEM\<22\> \
        ALU_result_EXMEM\<21\> ALU_result_EXMEM\<20\> \
        ALU_result_EXMEM\<19\> ALU_result_EXMEM\<18\> \
        ALU_result_EXMEM\<17\> ALU_result_EXMEM\<16\> \
        ALU_result_EXMEM\<15\> ALU_result_EXMEM\<14\> \
        ALU_result_EXMEM\<13\> ALU_result_EXMEM\<12\> \
        ALU_result_EXMEM\<11\> ALU_result_EXMEM\<10\> \
        ALU_result_EXMEM\<9\> ALU_result_EXMEM\<8\> ALU_result_EXMEM\<7\> \
        ALU_result_EXMEM\<6\> ALU_result_EXMEM\<5\> ALU_result_EXMEM\<4\> \
        ALU_result_EXMEM\<3\> ALU_result_EXMEM\<2\> ALU_result_EXMEM\<1\> \
        ALU_result_EXMEM\<0\> rs2_EX\<31\> rs2_EX\<30\> rs2_EX\<29\> \
        rs2_EX\<28\> rs2_EX\<27\> rs2_EX\<26\> rs2_EX\<25\> rs2_EX\<24\> \
        rs2_EX\<23\> rs2_EX\<22\> rs2_EX\<21\> rs2_EX\<20\> rs2_EX\<19\> \
        rs2_EX\<18\> rs2_EX\<17\> rs2_EX\<16\> rs2_EX\<15\> rs2_EX\<14\> \
        rs2_EX\<13\> rs2_EX\<12\> rs2_EX\<11\> rs2_EX\<10\> rs2_EX\<9\> \
        rs2_EX\<8\> rs2_EX\<7\> rs2_EX\<6\> rs2_EX\<5\> rs2_EX\<4\> \
        rs2_EX\<3\> rs2_EX\<2\> rs2_EX\<1\> rs2_EX\<0\> reg2_EXMEM\<31\> \
        reg2_EXMEM\<30\> reg2_EXMEM\<29\> reg2_EXMEM\<28\> \
        reg2_EXMEM\<27\> reg2_EXMEM\<26\> reg2_EXMEM\<25\> \
        reg2_EXMEM\<24\> reg2_EXMEM\<23\> reg2_EXMEM\<22\> \
        reg2_EXMEM\<21\> reg2_EXMEM\<20\> reg2_EXMEM\<19\> \
        reg2_EXMEM\<18\> reg2_EXMEM\<17\> reg2_EXMEM\<16\> \
        reg2_EXMEM\<15\> reg2_EXMEM\<14\> reg2_EXMEM\<13\> \
        reg2_EXMEM\<12\> reg2_EXMEM\<11\> reg2_EXMEM\<10\> reg2_EXMEM\<9\> \
        reg2_EXMEM\<8\> reg2_EXMEM\<7\> reg2_EXMEM\<6\> reg2_EXMEM\<5\> \
        reg2_EXMEM\<4\> reg2_EXMEM\<3\> reg2_EXMEM\<2\> reg2_EXMEM\<1\> \
        reg2_EXMEM\<0\> rs2_IDEX\<4\> rs2_IDEX\<3\> rs2_IDEX\<2\> \
        rs2_IDEX\<1\> rs2_IDEX\<0\> rs2_adr_EXMEM\<4\> rs2_adr_EXMEM\<3\> \
        rs2_adr_EXMEM\<2\> rs2_adr_EXMEM\<1\> rs2_adr_EXMEM\<0\> \
        branch_target_EXMEM\<10\> branch_target_EXMEM\<9\> \
        branch_target_EXMEM\<8\> branch_target_EXMEM\<7\> \
        branch_target_EXMEM\<6\> branch_target_EXMEM\<5\> \
        branch_target_EXMEM\<4\> branch_target_EXMEM\<3\> \
        branch_target_EXMEM\<2\> branch_target_EXMEM\<1\> \
        branch_target_EXMEM\<0\> branch_target_IDEX\<10\> \
        branch_target_IDEX\<9\> branch_target_IDEX\<8\> \
        branch_target_IDEX\<7\> branch_target_IDEX\<6\> \
        branch_target_IDEX\<5\> branch_target_IDEX\<4\> \
        branch_target_IDEX\<3\> branch_target_IDEX\<2\> \
        branch_target_IDEX\<1\> branch_target_IDEX\<0\> PC_incr_IDEX\<10\> \
        PC_incr_IDEX\<9\> PC_incr_IDEX\<8\> PC_incr_IDEX\<7\> \
        PC_incr_IDEX\<6\> PC_incr_IDEX\<5\> PC_incr_IDEX\<4\> \
        PC_incr_IDEX\<3\> PC_incr_IDEX\<2\> PC_incr_IDEX\<1\> \
        PC_incr_IDEX\<0\> PC_incr_EXMEM\<10\> PC_incr_EXMEM\<9\> \
        PC_incr_EXMEM\<8\> PC_incr_EXMEM\<7\> PC_incr_EXMEM\<6\> \
        PC_incr_EXMEM\<5\> PC_incr_EXMEM\<4\> PC_incr_EXMEM\<3\> \
        PC_incr_EXMEM\<2\> PC_incr_EXMEM\<1\> PC_incr_EXMEM\<0\> \
        mem_we_IDEX mem_re_IDEX mem_we_EXMEM mem_re_EXMEM mem_be_IDEX\<1\> \
        mem_be_IDEX\<0\> mem_be_EXMEM\<1\> mem_be_EXMEM\<0\> \
        is_branch_IDEX is_branch_EXMEM is_jump_IDEX is_jump_EXMEM \
        rd_IDEX\<4\> rd_IDEX\<3\> rd_IDEX\<2\> rd_IDEX\<1\> rd_IDEX\<0\> \
        wb_we_IDEX rd_EXMEM\<4\> rd_EXMEM\<3\> rd_EXMEM\<2\> rd_EXMEM\<1\> \
        rd_EXMEM\<0\> wb_we_EXMEM wb_src_IDEX\<1\> wb_src_IDEX\<0\> \
        wb_src_EXMEM\<1\> wb_src_EXMEM\<0\> mem_load_unsigned_IDEX \
        funct3_EXMEM\[2\] branched_IDEX branched_EXMEM inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_EXMEM_preg_schematic
    Execute (ALU_operation_IDEX\<3\> ALU_operation_IDEX\<2\> \
        ALU_operation_IDEX\<1\> ALU_operation_IDEX\<0\> reg1_IDEX\<31\> \
        reg1_IDEX\<30\> reg1_IDEX\<29\> reg1_IDEX\<28\> reg1_IDEX\<27\> \
        reg1_IDEX\<26\> reg1_IDEX\<25\> reg1_IDEX\<24\> reg1_IDEX\<23\> \
        reg1_IDEX\<22\> reg1_IDEX\<21\> reg1_IDEX\<20\> reg1_IDEX\<19\> \
        reg1_IDEX\<18\> reg1_IDEX\<17\> reg1_IDEX\<16\> reg1_IDEX\<15\> \
        reg1_IDEX\<14\> reg1_IDEX\<13\> reg1_IDEX\<12\> reg1_IDEX\<11\> \
        reg1_IDEX\<10\> reg1_IDEX\<9\> reg1_IDEX\<8\> reg1_IDEX\<7\> \
        reg1_IDEX\<6\> reg1_IDEX\<5\> reg1_IDEX\<4\> reg1_IDEX\<3\> \
        reg1_IDEX\<2\> reg1_IDEX\<1\> reg1_IDEX\<0\> reg2_IDEX\<31\> \
        reg2_IDEX\<30\> reg2_IDEX\<29\> reg2_IDEX\<28\> reg2_IDEX\<27\> \
        reg2_IDEX\<26\> reg2_IDEX\<25\> reg2_IDEX\<24\> reg2_IDEX\<23\> \
        reg2_IDEX\<22\> reg2_IDEX\<21\> reg2_IDEX\<20\> reg2_IDEX\<19\> \
        reg2_IDEX\<18\> reg2_IDEX\<17\> reg2_IDEX\<16\> reg2_IDEX\<15\> \
        reg2_IDEX\<14\> reg2_IDEX\<13\> reg2_IDEX\<12\> reg2_IDEX\<11\> \
        reg2_IDEX\<10\> reg2_IDEX\<9\> reg2_IDEX\<8\> reg2_IDEX\<7\> \
        reg2_IDEX\<6\> reg2_IDEX\<5\> reg2_IDEX\<4\> reg2_IDEX\<3\> \
        reg2_IDEX\<2\> reg2_IDEX\<1\> reg2_IDEX\<0\> imm_IDEX\<31\> \
        imm_IDEX\<30\> imm_IDEX\<29\> imm_IDEX\<28\> imm_IDEX\<27\> \
        imm_IDEX\<26\> imm_IDEX\<25\> imm_IDEX\<24\> imm_IDEX\<23\> \
        imm_IDEX\<22\> imm_IDEX\<21\> imm_IDEX\<20\> imm_IDEX\<19\> \
        imm_IDEX\<18\> imm_IDEX\<17\> imm_IDEX\<16\> imm_IDEX\<15\> \
        imm_IDEX\<14\> imm_IDEX\<13\> imm_IDEX\<12\> imm_IDEX\<11\> \
        imm_IDEX\<10\> imm_IDEX\<9\> imm_IDEX\<8\> imm_IDEX\<7\> \
        imm_IDEX\<6\> imm_IDEX\<5\> imm_IDEX\<4\> imm_IDEX\<3\> \
        imm_IDEX\<2\> imm_IDEX\<1\> imm_IDEX\<0\> is_imm_IDEX \
        rs1_IDEX\<4\> rs1_IDEX\<3\> rs1_IDEX\<2\> rs1_IDEX\<1\> \
        rs1_IDEX\<0\> rs2_IDEX\<4\> rs2_IDEX\<3\> rs2_IDEX\<2\> \
        rs2_IDEX\<1\> rs2_IDEX\<0\> rs2_EX\<31\> rs2_EX\<30\> rs2_EX\<29\> \
        rs2_EX\<28\> rs2_EX\<27\> rs2_EX\<26\> rs2_EX\<25\> rs2_EX\<24\> \
        rs2_EX\<23\> rs2_EX\<22\> rs2_EX\<21\> rs2_EX\<20\> rs2_EX\<19\> \
        rs2_EX\<18\> rs2_EX\<17\> rs2_EX\<16\> rs2_EX\<15\> rs2_EX\<14\> \
        rs2_EX\<13\> rs2_EX\<12\> rs2_EX\<11\> rs2_EX\<10\> rs2_EX\<9\> \
        rs2_EX\<8\> rs2_EX\<7\> rs2_EX\<6\> rs2_EX\<5\> rs2_EX\<4\> \
        rs2_EX\<3\> rs2_EX\<2\> rs2_EX\<1\> rs2_EX\<0\> rd_IDEX\<4\> \
        rd_IDEX\<3\> rd_IDEX\<2\> rd_IDEX\<1\> rd_IDEX\<0\> \
        current_PC_IDEX\<10\> current_PC_IDEX\<9\> current_PC_IDEX\<8\> \
        current_PC_IDEX\<7\> current_PC_IDEX\<6\> current_PC_IDEX\<5\> \
        current_PC_IDEX\<4\> current_PC_IDEX\<3\> current_PC_IDEX\<2\> \
        current_PC_IDEX\<1\> current_PC_IDEX\<0\> reg_or_PC_IDEX \
        rd_EXMEM\<4\> rd_EXMEM\<3\> rd_EXMEM\<2\> rd_EXMEM\<1\> \
        rd_EXMEM\<0\> rs2_adr_EXMEM\<4\> rs2_adr_EXMEM\<3\> \
        rs2_adr_EXMEM\<2\> rs2_adr_EXMEM\<1\> rs2_adr_EXMEM\<0\> \
        ALU_result_EXMEM\<31\> ALU_result_EXMEM\<30\> \
        ALU_result_EXMEM\<29\> ALU_result_EXMEM\<28\> \
        ALU_result_EXMEM\<27\> ALU_result_EXMEM\<26\> \
        ALU_result_EXMEM\<25\> ALU_result_EXMEM\<24\> \
        ALU_result_EXMEM\<23\> ALU_result_EXMEM\<22\> \
        ALU_result_EXMEM\<21\> ALU_result_EXMEM\<20\> \
        ALU_result_EXMEM\<19\> ALU_result_EXMEM\<18\> \
        ALU_result_EXMEM\<17\> ALU_result_EXMEM\<16\> \
        ALU_result_EXMEM\<15\> ALU_result_EXMEM\<14\> \
        ALU_result_EXMEM\<13\> ALU_result_EXMEM\<12\> \
        ALU_result_EXMEM\<11\> ALU_result_EXMEM\<10\> \
        ALU_result_EXMEM\<9\> ALU_result_EXMEM\<8\> ALU_result_EXMEM\<7\> \
        ALU_result_EXMEM\<6\> ALU_result_EXMEM\<5\> ALU_result_EXMEM\<4\> \
        ALU_result_EXMEM\<3\> ALU_result_EXMEM\<2\> ALU_result_EXMEM\<1\> \
        ALU_result_EXMEM\<0\> wb_we_EXMEM rd_MEMWB\<4\> rd_MEMWB\<3\> \
        rd_MEMWB\<2\> rd_MEMWB\<1\> rd_MEMWB\<0\> wb_data_WB\<31\> \
        wb_data_WB\<30\> wb_data_WB\<29\> wb_data_WB\<28\> \
        wb_data_WB\<27\> wb_data_WB\<26\> wb_data_WB\<25\> \
        wb_data_WB\<24\> wb_data_WB\<23\> wb_data_WB\<22\> \
        wb_data_WB\<21\> wb_data_WB\<20\> wb_data_WB\<19\> \
        wb_data_WB\<18\> wb_data_WB\<17\> wb_data_WB\<16\> \
        wb_data_WB\<15\> wb_data_WB\<14\> wb_data_WB\<13\> \
        wb_data_WB\<12\> wb_data_WB\<11\> wb_data_WB\<10\> wb_data_WB\<9\> \
        wb_data_WB\<8\> wb_data_WB\<7\> wb_data_WB\<6\> wb_data_WB\<5\> \
        wb_data_WB\<4\> wb_data_WB\<3\> wb_data_WB\<2\> wb_data_WB\<1\> \
        wb_data_WB\<0\> wb_we_MEMWB ALU_result_EX\<31\> \
        ALU_result_EX\<30\> ALU_result_EX\<29\> ALU_result_EX\<28\> \
        ALU_result_EX\<27\> ALU_result_EX\<26\> ALU_result_EX\<25\> \
        ALU_result_EX\<24\> ALU_result_EX\<23\> ALU_result_EX\<22\> \
        ALU_result_EX\<21\> ALU_result_EX\<20\> ALU_result_EX\<19\> \
        ALU_result_EX\<18\> ALU_result_EX\<17\> ALU_result_EX\<16\> \
        ALU_result_EX\<15\> ALU_result_EX\<14\> ALU_result_EX\<13\> \
        ALU_result_EX\<12\> ALU_result_EX\<11\> ALU_result_EX\<10\> \
        ALU_result_EX\<9\> ALU_result_EX\<8\> ALU_result_EX\<7\> \
        ALU_result_EX\<6\> ALU_result_EX\<5\> ALU_result_EX\<4\> \
        ALU_result_EX\<3\> ALU_result_EX\<2\> ALU_result_EX\<1\> \
        ALU_result_EX\<0\> mem_rs2_src_EX inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_execute_schematic
    memory (clk ALU_result_EXMEM\<31\> ALU_result_EXMEM\<30\> \
        ALU_result_EXMEM\<29\> ALU_result_EXMEM\<28\> \
        ALU_result_EXMEM\<27\> ALU_result_EXMEM\<26\> \
        ALU_result_EXMEM\<25\> ALU_result_EXMEM\<24\> \
        ALU_result_EXMEM\<23\> ALU_result_EXMEM\<22\> \
        ALU_result_EXMEM\<21\> ALU_result_EXMEM\<20\> \
        ALU_result_EXMEM\<19\> ALU_result_EXMEM\<18\> \
        ALU_result_EXMEM\<17\> ALU_result_EXMEM\<16\> \
        ALU_result_EXMEM\<15\> ALU_result_EXMEM\<14\> \
        ALU_result_EXMEM\<13\> ALU_result_EXMEM\<12\> \
        ALU_result_EXMEM\<11\> ALU_result_EXMEM\<10\> \
        ALU_result_EXMEM\<9\> ALU_result_EXMEM\<8\> ALU_result_EXMEM\<7\> \
        ALU_result_EXMEM\<6\> ALU_result_EXMEM\<5\> ALU_result_EXMEM\<4\> \
        ALU_result_EXMEM\<3\> ALU_result_EXMEM\<2\> ALU_result_EXMEM\<1\> \
        ALU_result_EXMEM\<0\> reg2_EXMEM\<31\> reg2_EXMEM\<30\> \
        reg2_EXMEM\<29\> reg2_EXMEM\<28\> reg2_EXMEM\<27\> \
        reg2_EXMEM\<26\> reg2_EXMEM\<25\> reg2_EXMEM\<24\> \
        reg2_EXMEM\<23\> reg2_EXMEM\<22\> reg2_EXMEM\<21\> \
        reg2_EXMEM\<20\> reg2_EXMEM\<19\> reg2_EXMEM\<18\> \
        reg2_EXMEM\<17\> reg2_EXMEM\<16\> reg2_EXMEM\<15\> \
        reg2_EXMEM\<14\> reg2_EXMEM\<13\> reg2_EXMEM\<12\> \
        reg2_EXMEM\<11\> reg2_EXMEM\<10\> reg2_EXMEM\<9\> reg2_EXMEM\<8\> \
        reg2_EXMEM\<7\> reg2_EXMEM\<6\> reg2_EXMEM\<5\> reg2_EXMEM\<4\> \
        reg2_EXMEM\<3\> reg2_EXMEM\<2\> reg2_EXMEM\<1\> reg2_EXMEM\<0\> \
        wb_data_WB\<31\> wb_data_WB\<30\> wb_data_WB\<29\> \
        wb_data_WB\<28\> wb_data_WB\<27\> wb_data_WB\<26\> \
        wb_data_WB\<25\> wb_data_WB\<24\> wb_data_WB\<23\> \
        wb_data_WB\<22\> wb_data_WB\<21\> wb_data_WB\<20\> \
        wb_data_WB\<19\> wb_data_WB\<18\> wb_data_WB\<17\> \
        wb_data_WB\<16\> wb_data_WB\<15\> wb_data_WB\<14\> \
        wb_data_WB\<13\> wb_data_WB\<12\> wb_data_WB\<11\> \
        wb_data_WB\<10\> wb_data_WB\<9\> wb_data_WB\<8\> wb_data_WB\<7\> \
        wb_data_WB\<6\> wb_data_WB\<5\> wb_data_WB\<4\> wb_data_WB\<3\> \
        wb_data_WB\<2\> wb_data_WB\<1\> wb_data_WB\<0\> mem_rs2_src_EX \
        mem_be_EXMEM\<1\> mem_be_EXMEM\<0\> mem_we_EXMEM mem_re_EXMEM \
        is_branch_EXMEM funct3_EXMEM\[2\] mem_be_EXMEM\<1\> \
        mem_be_EXMEM\<0\> is_jump_EXMEM new_PC_MEM\<10\> new_PC_MEM\<9\> \
        new_PC_MEM\<8\> new_PC_MEM\<7\> new_PC_MEM\<6\> new_PC_MEM\<5\> \
        new_PC_MEM\<4\> new_PC_MEM\<3\> new_PC_MEM\<2\> new_PC_MEM\<1\> \
        new_PC_MEM\<0\> branch_target_EXMEM\<10\> branch_target_EXMEM\<9\> \
        branch_target_EXMEM\<8\> branch_target_EXMEM\<7\> \
        branch_target_EXMEM\<6\> branch_target_EXMEM\<5\> \
        branch_target_EXMEM\<4\> branch_target_EXMEM\<3\> \
        branch_target_EXMEM\<2\> branch_target_EXMEM\<1\> \
        branch_target_EXMEM\<0\> control_transfer_MEM branched_EXMEM \
        PC_incr_EXMEM\<10\> PC_incr_EXMEM\<9\> PC_incr_EXMEM\<8\> \
        PC_incr_EXMEM\<7\> PC_incr_EXMEM\<6\> PC_incr_EXMEM\<5\> \
        PC_incr_EXMEM\<4\> PC_incr_EXMEM\<3\> PC_incr_EXMEM\<2\> \
        PC_incr_EXMEM\<1\> PC_incr_EXMEM\<0\> branch_MEM \
        data_memory_be\<1\> data_memory_be\<0\> data_memory_address\<11\> \
        data_memory_address\<10\> data_memory_address\<9\> \
        data_memory_address\<8\> data_memory_address\<7\> \
        data_memory_address\<6\> data_memory_address\<5\> \
        data_memory_address\<4\> data_memory_address\<3\> \
        data_memory_address\<2\> data_memory_address\<1\> \
        data_memory_address\<0\> data_memory_write_enable \
        data_memory_read_enable data_memory_write_data\<31\> \
        data_memory_write_data\<30\> data_memory_write_data\<29\> \
        data_memory_write_data\<28\> data_memory_write_data\<27\> \
        data_memory_write_data\<26\> data_memory_write_data\<25\> \
        data_memory_write_data\<24\> data_memory_write_data\<23\> \
        data_memory_write_data\<22\> data_memory_write_data\<21\> \
        data_memory_write_data\<20\> data_memory_write_data\<19\> \
        data_memory_write_data\<18\> data_memory_write_data\<17\> \
        data_memory_write_data\<16\> data_memory_write_data\<15\> \
        data_memory_write_data\<14\> data_memory_write_data\<13\> \
        data_memory_write_data\<12\> data_memory_write_data\<11\> \
        data_memory_write_data\<10\> data_memory_write_data\<9\> \
        data_memory_write_data\<8\> data_memory_write_data\<7\> \
        data_memory_write_data\<6\> data_memory_write_data\<5\> \
        data_memory_write_data\<4\> data_memory_write_data\<3\> \
        data_memory_write_data\<2\> data_memory_write_data\<1\> \
        data_memory_write_data\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_memory_schematic
    activity_control (clk n2 stall_ID nreset control_transfer_MEM \
        init_sleep counter_enable stall_IF stall flush_IFID flush_IDEX \
        flush_EXMEM flush_MEMWB inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_activity_control_schematic
    IFID_pipline_register (clk flush_IFID stall instruction_IF\<31\> \
        instruction_IF\<30\> instruction_IF\<29\> instruction_IF\<28\> \
        instruction_IF\<27\> instruction_IF\<26\> instruction_IF\<25\> \
        instruction_IF\<24\> instruction_IF\<23\> instruction_IF\<22\> \
        instruction_IF\<21\> instruction_IF\<20\> instruction_IF\<19\> \
        instruction_IF\<18\> instruction_IF\<17\> instruction_IF\<16\> \
        instruction_IF\<15\> instruction_IF\<14\> instruction_IF\<13\> \
        instruction_IF\<12\> instruction_IF\<11\> instruction_IF\<10\> \
        instruction_IF\<9\> instruction_IF\<8\> instruction_IF\<7\> \
        instruction_IF\<6\> instruction_IF\<5\> instruction_IF\<4\> \
        instruction_IF\<3\> instruction_IF\<2\> instruction_IF\<1\> \
        instruction_IF\<0\> branch_target_IF\<10\> branch_target_IF\<9\> \
        branch_target_IF\<8\> branch_target_IF\<7\> branch_target_IF\<6\> \
        branch_target_IF\<5\> branch_target_IF\<4\> branch_target_IF\<3\> \
        branch_target_IF\<2\> branch_target_IF\<1\> branch_target_IF\<0\> \
        branch_target_IFID\<10\> branch_target_IFID\<9\> \
        branch_target_IFID\<8\> branch_target_IFID\<7\> \
        branch_target_IFID\<6\> branch_target_IFID\<5\> \
        branch_target_IFID\<4\> branch_target_IFID\<3\> \
        branch_target_IFID\<2\> branch_target_IFID\<1\> \
        branch_target_IFID\<0\> instruction_IFID\<31\> \
        instruction_IFID\<30\> instruction_IFID\<29\> \
        instruction_IFID\<28\> instruction_IFID\<27\> \
        instruction_IFID\<26\> instruction_IFID\<25\> \
        instruction_IFID\<24\> instruction_IFID\<23\> \
        instruction_IFID\<22\> instruction_IFID\<21\> \
        instruction_IFID\<20\> instruction_IFID\<19\> \
        instruction_IFID\<18\> instruction_IFID\<17\> \
        instruction_IFID\<16\> instruction_IFID\<15\> \
        instruction_IFID\<14\> instruction_IFID\<13\> \
        instruction_IFID\<12\> instruction_IFID\<11\> \
        instruction_IFID\<10\> instruction_IFID\<9\> instruction_IFID\<8\> \
        instruction_IFID\<7\> instruction_IFID\<6\> instruction_IFID\<5\> \
        instruction_IFID\<4\> instruction_IFID\<3\> instruction_IFID\<2\> \
        instruction_IFID\<1\> instruction_IFID\<0\> current_PC_IF\<10\> \
        current_PC_IF\<9\> current_PC_IF\<8\> current_PC_IF\<7\> \
        current_PC_IF\<6\> current_PC_IF\<5\> current_PC_IF\<4\> \
        current_PC_IF\<3\> current_PC_IF\<2\> current_PC_IF\<1\> \
        current_PC_IF\<0\> current_PC_IFID\<10\> current_PC_IFID\<9\> \
        current_PC_IFID\<8\> current_PC_IFID\<7\> current_PC_IFID\<6\> \
        current_PC_IFID\<5\> current_PC_IFID\<4\> current_PC_IFID\<3\> \
        current_PC_IFID\<2\> current_PC_IFID\<1\> current_PC_IFID\<0\> \
        PC_incr_IF\<10\> PC_incr_IF\<9\> PC_incr_IF\<8\> PC_incr_IF\<7\> \
        PC_incr_IF\<6\> PC_incr_IF\<5\> PC_incr_IF\<4\> PC_incr_IF\<3\> \
        PC_incr_IF\<2\> PC_incr_IF\<1\> PC_incr_IF\<0\> PC_incr_IFID\<10\> \
        PC_incr_IFID\<9\> PC_incr_IFID\<8\> PC_incr_IFID\<7\> \
        PC_incr_IFID\<6\> PC_incr_IFID\<5\> PC_incr_IFID\<4\> \
        PC_incr_IFID\<3\> PC_incr_IFID\<2\> PC_incr_IFID\<1\> \
        PC_incr_IFID\<0\> branched_IF branched_IFID inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_IFID_preg_schematic
    write_back (wb_src_MEMWB\<1\> wb_src_MEMWB\<0\> mem_read_MEMWB\<31\> \
        mem_read_MEMWB\<30\> mem_read_MEMWB\<29\> mem_read_MEMWB\<28\> \
        mem_read_MEMWB\<27\> mem_read_MEMWB\<26\> mem_read_MEMWB\<25\> \
        mem_read_MEMWB\<24\> mem_read_MEMWB\<23\> mem_read_MEMWB\<22\> \
        mem_read_MEMWB\<21\> mem_read_MEMWB\<20\> mem_read_MEMWB\<19\> \
        mem_read_MEMWB\<18\> mem_read_MEMWB\<17\> mem_read_MEMWB\<16\> \
        mem_read_MEMWB\<15\> mem_read_MEMWB\<14\> mem_read_MEMWB\<13\> \
        mem_read_MEMWB\<12\> mem_read_MEMWB\<11\> mem_read_MEMWB\<10\> \
        mem_read_MEMWB\<9\> mem_read_MEMWB\<8\> mem_read_MEMWB\<7\> \
        mem_read_MEMWB\<6\> mem_read_MEMWB\<5\> mem_read_MEMWB\<4\> \
        mem_read_MEMWB\<3\> mem_read_MEMWB\<2\> mem_read_MEMWB\<1\> \
        mem_read_MEMWB\<0\> ALU_result_MEMWB\<31\> ALU_result_MEMWB\<30\> \
        ALU_result_MEMWB\<29\> ALU_result_MEMWB\<28\> \
        ALU_result_MEMWB\<27\> ALU_result_MEMWB\<26\> \
        ALU_result_MEMWB\<25\> ALU_result_MEMWB\<24\> \
        ALU_result_MEMWB\<23\> ALU_result_MEMWB\<22\> \
        ALU_result_MEMWB\<21\> ALU_result_MEMWB\<20\> \
        ALU_result_MEMWB\<19\> ALU_result_MEMWB\<18\> \
        ALU_result_MEMWB\<17\> ALU_result_MEMWB\<16\> \
        ALU_result_MEMWB\<15\> ALU_result_MEMWB\<14\> \
        ALU_result_MEMWB\<13\> ALU_result_MEMWB\<12\> \
        ALU_result_MEMWB\<11\> ALU_result_MEMWB\<10\> \
        ALU_result_MEMWB\<9\> ALU_result_MEMWB\<8\> ALU_result_MEMWB\<7\> \
        ALU_result_MEMWB\<6\> ALU_result_MEMWB\<5\> ALU_result_MEMWB\<4\> \
        ALU_result_MEMWB\<3\> ALU_result_MEMWB\<2\> ALU_result_MEMWB\<1\> \
        ALU_result_MEMWB\<0\> wb_data_WB\<31\> wb_data_WB\<30\> \
        wb_data_WB\<29\> wb_data_WB\<28\> wb_data_WB\<27\> \
        wb_data_WB\<26\> wb_data_WB\<25\> wb_data_WB\<24\> \
        wb_data_WB\<23\> wb_data_WB\<22\> wb_data_WB\<21\> \
        wb_data_WB\<20\> wb_data_WB\<19\> wb_data_WB\<18\> \
        wb_data_WB\<17\> wb_data_WB\<16\> wb_data_WB\<15\> \
        wb_data_WB\<14\> wb_data_WB\<13\> wb_data_WB\<12\> \
        wb_data_WB\<11\> wb_data_WB\<10\> wb_data_WB\<9\> wb_data_WB\<8\> \
        wb_data_WB\<7\> wb_data_WB\<6\> wb_data_WB\<5\> wb_data_WB\<4\> \
        wb_data_WB\<3\> wb_data_WB\<2\> wb_data_WB\<1\> wb_data_WB\<0\> \
        mem_load_width_MEMWB\<1\> mem_load_width_MEMWB\<0\> \
        mem_load_unsigned_MEMWB PC_incr_MEMWB\<10\> PC_incr_MEMWB\<9\> \
        PC_incr_MEMWB\<8\> PC_incr_MEMWB\<7\> PC_incr_MEMWB\<6\> \
        PC_incr_MEMWB\<5\> PC_incr_MEMWB\<4\> PC_incr_MEMWB\<3\> \
        PC_incr_MEMWB\<2\> PC_incr_MEMWB\<1\> PC_incr_MEMWB\<0\> \
        clock_count\<63\> clock_count\<62\> clock_count\<61\> \
        clock_count\<60\> clock_count\<59\> clock_count\<58\> \
        clock_count\<57\> clock_count\<56\> clock_count\<55\> \
        clock_count\<54\> clock_count\<53\> clock_count\<52\> \
        clock_count\<51\> clock_count\<50\> clock_count\<49\> \
        clock_count\<48\> clock_count\<47\> clock_count\<46\> \
        clock_count\<45\> clock_count\<44\> clock_count\<43\> \
        clock_count\<42\> clock_count\<41\> clock_count\<40\> \
        clock_count\<39\> clock_count\<38\> clock_count\<37\> \
        clock_count\<36\> clock_count\<35\> clock_count\<34\> \
        clock_count\<33\> clock_count\<32\> clock_count\<31\> \
        clock_count\<30\> clock_count\<29\> clock_count\<28\> \
        clock_count\<27\> clock_count\<26\> clock_count\<25\> \
        clock_count\<24\> clock_count\<23\> clock_count\<22\> \
        clock_count\<21\> clock_count\<20\> clock_count\<19\> \
        clock_count\<18\> clock_count\<17\> clock_count\<16\> \
        clock_count\<15\> clock_count\<14\> clock_count\<13\> \
        clock_count\<12\> clock_count\<11\> clock_count\<10\> \
        clock_count\<9\> clock_count\<8\> clock_count\<7\> \
        clock_count\<6\> clock_count\<5\> clock_count\<4\> \
        clock_count\<3\> clock_count\<2\> clock_count\<1\> \
        clock_count\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_write_back_schematic
    MEMWB_pipeline_registers (clk flush_MEMWB data_memory_read_data\<31\> \
        data_memory_read_data\<30\> data_memory_read_data\<29\> \
        data_memory_read_data\<28\> data_memory_read_data\<27\> \
        data_memory_read_data\<26\> data_memory_read_data\<25\> \
        data_memory_read_data\<24\> data_memory_read_data\<23\> \
        data_memory_read_data\<22\> data_memory_read_data\<21\> \
        data_memory_read_data\<20\> data_memory_read_data\<19\> \
        data_memory_read_data\<18\> data_memory_read_data\<17\> \
        data_memory_read_data\<16\> data_memory_read_data\<15\> \
        data_memory_read_data\<14\> data_memory_read_data\<13\> \
        data_memory_read_data\<12\> data_memory_read_data\<11\> \
        data_memory_read_data\<10\> data_memory_read_data\<9\> \
        data_memory_read_data\<8\> data_memory_read_data\<7\> \
        data_memory_read_data\<6\> data_memory_read_data\<5\> \
        data_memory_read_data\<4\> data_memory_read_data\<3\> \
        data_memory_read_data\<2\> data_memory_read_data\<1\> \
        data_memory_read_data\<0\> mem_read_MEMWB\<31\> \
        mem_read_MEMWB\<30\> mem_read_MEMWB\<29\> mem_read_MEMWB\<28\> \
        mem_read_MEMWB\<27\> mem_read_MEMWB\<26\> mem_read_MEMWB\<25\> \
        mem_read_MEMWB\<24\> mem_read_MEMWB\<23\> mem_read_MEMWB\<22\> \
        mem_read_MEMWB\<21\> mem_read_MEMWB\<20\> mem_read_MEMWB\<19\> \
        mem_read_MEMWB\<18\> mem_read_MEMWB\<17\> mem_read_MEMWB\<16\> \
        mem_read_MEMWB\<15\> mem_read_MEMWB\<14\> mem_read_MEMWB\<13\> \
        mem_read_MEMWB\<12\> mem_read_MEMWB\<11\> mem_read_MEMWB\<10\> \
        mem_read_MEMWB\<9\> mem_read_MEMWB\<8\> mem_read_MEMWB\<7\> \
        mem_read_MEMWB\<6\> mem_read_MEMWB\<5\> mem_read_MEMWB\<4\> \
        mem_read_MEMWB\<3\> mem_read_MEMWB\<2\> mem_read_MEMWB\<1\> \
        mem_read_MEMWB\<0\> ALU_result_EXMEM\<31\> ALU_result_EXMEM\<30\> \
        ALU_result_EXMEM\<29\> ALU_result_EXMEM\<28\> \
        ALU_result_EXMEM\<27\> ALU_result_EXMEM\<26\> \
        ALU_result_EXMEM\<25\> ALU_result_EXMEM\<24\> \
        ALU_result_EXMEM\<23\> ALU_result_EXMEM\<22\> \
        ALU_result_EXMEM\<21\> ALU_result_EXMEM\<20\> \
        ALU_result_EXMEM\<19\> ALU_result_EXMEM\<18\> \
        ALU_result_EXMEM\<17\> ALU_result_EXMEM\<16\> \
        ALU_result_EXMEM\<15\> ALU_result_EXMEM\<14\> \
        ALU_result_EXMEM\<13\> ALU_result_EXMEM\<12\> \
        ALU_result_EXMEM\<11\> ALU_result_EXMEM\<10\> \
        ALU_result_EXMEM\<9\> ALU_result_EXMEM\<8\> ALU_result_EXMEM\<7\> \
        ALU_result_EXMEM\<6\> ALU_result_EXMEM\<5\> ALU_result_EXMEM\<4\> \
        ALU_result_EXMEM\<3\> ALU_result_EXMEM\<2\> ALU_result_EXMEM\<1\> \
        ALU_result_EXMEM\<0\> ALU_result_MEMWB\<31\> \
        ALU_result_MEMWB\<30\> ALU_result_MEMWB\<29\> \
        ALU_result_MEMWB\<28\> ALU_result_MEMWB\<27\> \
        ALU_result_MEMWB\<26\> ALU_result_MEMWB\<25\> \
        ALU_result_MEMWB\<24\> ALU_result_MEMWB\<23\> \
        ALU_result_MEMWB\<22\> ALU_result_MEMWB\<21\> \
        ALU_result_MEMWB\<20\> ALU_result_MEMWB\<19\> \
        ALU_result_MEMWB\<18\> ALU_result_MEMWB\<17\> \
        ALU_result_MEMWB\<16\> ALU_result_MEMWB\<15\> \
        ALU_result_MEMWB\<14\> ALU_result_MEMWB\<13\> \
        ALU_result_MEMWB\<12\> ALU_result_MEMWB\<11\> \
        ALU_result_MEMWB\<10\> ALU_result_MEMWB\<9\> ALU_result_MEMWB\<8\> \
        ALU_result_MEMWB\<7\> ALU_result_MEMWB\<6\> ALU_result_MEMWB\<5\> \
        ALU_result_MEMWB\<4\> ALU_result_MEMWB\<3\> ALU_result_MEMWB\<2\> \
        ALU_result_MEMWB\<1\> ALU_result_MEMWB\<0\> wb_src_EXMEM\<1\> \
        wb_src_EXMEM\<0\> wb_src_MEMWB\<1\> wb_src_MEMWB\<0\> wb_we_EXMEM \
        wb_we_MEMWB rd_EXMEM\<4\> rd_EXMEM\<3\> rd_EXMEM\<2\> \
        rd_EXMEM\<1\> rd_EXMEM\<0\> rd_MEMWB\<4\> rd_MEMWB\<3\> \
        rd_MEMWB\<2\> rd_MEMWB\<1\> rd_MEMWB\<0\> mem_be_EXMEM\<1\> \
        mem_be_EXMEM\<0\> mem_load_width_MEMWB\<1\> \
        mem_load_width_MEMWB\<0\> funct3_EXMEM\[2\] \
        mem_load_unsigned_MEMWB PC_incr_EXMEM\<10\> PC_incr_EXMEM\<9\> \
        PC_incr_EXMEM\<8\> PC_incr_EXMEM\<7\> PC_incr_EXMEM\<6\> \
        PC_incr_EXMEM\<5\> PC_incr_EXMEM\<4\> PC_incr_EXMEM\<3\> \
        PC_incr_EXMEM\<2\> PC_incr_EXMEM\<1\> PC_incr_EXMEM\<0\> \
        PC_incr_MEMWB\<10\> PC_incr_MEMWB\<9\> PC_incr_MEMWB\<8\> \
        PC_incr_MEMWB\<7\> PC_incr_MEMWB\<6\> PC_incr_MEMWB\<5\> \
        PC_incr_MEMWB\<4\> PC_incr_MEMWB\<3\> PC_incr_MEMWB\<2\> \
        PC_incr_MEMWB\<1\> PC_incr_MEMWB\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_MEMWB_preg_schematic
    counter (clk counter_enable n13 clock_count\<63\> clock_count\<62\> \
        clock_count\<61\> clock_count\<60\> clock_count\<59\> \
        clock_count\<58\> clock_count\<57\> clock_count\<56\> \
        clock_count\<55\> clock_count\<54\> clock_count\<53\> \
        clock_count\<52\> clock_count\<51\> clock_count\<50\> \
        clock_count\<49\> clock_count\<48\> clock_count\<47\> \
        clock_count\<46\> clock_count\<45\> clock_count\<44\> \
        clock_count\<43\> clock_count\<42\> clock_count\<41\> \
        clock_count\<40\> clock_count\<39\> clock_count\<38\> \
        clock_count\<37\> clock_count\<36\> clock_count\<35\> \
        clock_count\<34\> clock_count\<33\> clock_count\<32\> \
        clock_count\<31\> clock_count\<30\> clock_count\<29\> \
        clock_count\<28\> clock_count\<27\> clock_count\<26\> \
        clock_count\<25\> clock_count\<24\> clock_count\<23\> \
        clock_count\<22\> clock_count\<21\> clock_count\<20\> \
        clock_count\<19\> clock_count\<18\> clock_count\<17\> \
        clock_count\<16\> clock_count\<15\> clock_count\<14\> \
        clock_count\<13\> clock_count\<12\> clock_count\<11\> \
        clock_count\<10\> clock_count\<9\> clock_count\<8\> \
        clock_count\<7\> clock_count\<6\> clock_count\<5\> \
        clock_count\<4\> clock_count\<3\> clock_count\<2\> \
        clock_count\<1\> clock_count\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_clock_counter_schematic
    instruction_decode (clk n12 instruction_IFID\<31\> \
        instruction_IFID\<30\> instruction_IFID\<29\> \
        instruction_IFID\<28\> instruction_IFID\<27\> \
        instruction_IFID\<26\> instruction_IFID\<25\> \
        instruction_IFID\<24\> instruction_IFID\<23\> \
        instruction_IFID\<22\> instruction_IFID\<21\> \
        instruction_IFID\<20\> instruction_IFID\<19\> \
        instruction_IFID\<18\> instruction_IFID\<17\> \
        instruction_IFID\<16\> instruction_IFID\<15\> \
        instruction_IFID\<14\> instruction_IFID\<13\> \
        instruction_IFID\<12\> instruction_IFID\<11\> \
        instruction_IFID\<10\> instruction_IFID\<9\> instruction_IFID\<8\> \
        instruction_IFID\<7\> instruction_IFID\<6\> instruction_IFID\<5\> \
        instruction_IFID\<4\> instruction_IFID\<3\> instruction_IFID\<2\> \
        instruction_IFID\<1\> instruction_IFID\<0\> rd_MEMWB\<4\> \
        rd_MEMWB\<3\> rd_MEMWB\<2\> rd_MEMWB\<1\> rd_MEMWB\<0\> \
        wb_data_WB\<31\> wb_data_WB\<30\> wb_data_WB\<29\> \
        wb_data_WB\<28\> wb_data_WB\<27\> wb_data_WB\<26\> \
        wb_data_WB\<25\> wb_data_WB\<24\> wb_data_WB\<23\> \
        wb_data_WB\<22\> wb_data_WB\<21\> wb_data_WB\<20\> \
        wb_data_WB\<19\> wb_data_WB\<18\> wb_data_WB\<17\> \
        wb_data_WB\<16\> wb_data_WB\<15\> wb_data_WB\<14\> \
        wb_data_WB\<13\> wb_data_WB\<12\> wb_data_WB\<11\> \
        wb_data_WB\<10\> wb_data_WB\<9\> wb_data_WB\<8\> wb_data_WB\<7\> \
        wb_data_WB\<6\> wb_data_WB\<5\> wb_data_WB\<4\> wb_data_WB\<3\> \
        wb_data_WB\<2\> wb_data_WB\<1\> wb_data_WB\<0\> wb_we_MEMWB \
        reg1_ID\<31\> reg1_ID\<30\> reg1_ID\<29\> reg1_ID\<28\> \
        reg1_ID\<27\> reg1_ID\<26\> reg1_ID\<25\> reg1_ID\<24\> \
        reg1_ID\<23\> reg1_ID\<22\> reg1_ID\<21\> reg1_ID\<20\> \
        reg1_ID\<19\> reg1_ID\<18\> reg1_ID\<17\> reg1_ID\<16\> \
        reg1_ID\<15\> reg1_ID\<14\> reg1_ID\<13\> reg1_ID\<12\> \
        reg1_ID\<11\> reg1_ID\<10\> reg1_ID\<9\> reg1_ID\<8\> reg1_ID\<7\> \
        reg1_ID\<6\> reg1_ID\<5\> reg1_ID\<4\> reg1_ID\<3\> reg1_ID\<2\> \
        reg1_ID\<1\> reg1_ID\<0\> reg2_ID\<31\> reg2_ID\<30\> \
        reg2_ID\<29\> reg2_ID\<28\> reg2_ID\<27\> reg2_ID\<26\> \
        reg2_ID\<25\> reg2_ID\<24\> reg2_ID\<23\> reg2_ID\<22\> \
        reg2_ID\<21\> reg2_ID\<20\> reg2_ID\<19\> reg2_ID\<18\> \
        reg2_ID\<17\> reg2_ID\<16\> reg2_ID\<15\> reg2_ID\<14\> \
        reg2_ID\<13\> reg2_ID\<12\> reg2_ID\<11\> reg2_ID\<10\> \
        reg2_ID\<9\> reg2_ID\<8\> reg2_ID\<7\> reg2_ID\<6\> reg2_ID\<5\> \
        reg2_ID\<4\> reg2_ID\<3\> reg2_ID\<2\> reg2_ID\<1\> reg2_ID\<0\> \
        imm_ID\<31\> imm_ID\<30\> imm_ID\<29\> imm_ID\<28\> imm_ID\<27\> \
        imm_ID\<26\> imm_ID\<25\> imm_ID\<24\> imm_ID\<23\> imm_ID\<22\> \
        imm_ID\<21\> imm_ID\<20\> imm_ID\<19\> imm_ID\<18\> imm_ID\<17\> \
        imm_ID\<16\> imm_ID\<15\> imm_ID\<14\> imm_ID\<13\> imm_ID\<12\> \
        imm_ID\<11\> imm_ID\<10\> imm_ID\<9\> imm_ID\<8\> imm_ID\<7\> \
        imm_ID\<6\> imm_ID\<5\> imm_ID\<4\> imm_ID\<3\> imm_ID\<2\> \
        imm_ID\<1\> imm_ID\<0\> is_imm_ID rs1_ID\<4\> rs1_ID\<3\> \
        rs1_ID\<2\> rs1_ID\<1\> rs1_ID\<0\> rs2_ID\<4\> rs2_ID\<3\> \
        rs2_ID\<2\> rs2_ID\<1\> rs2_ID\<0\> rd_ID\<4\> rd_ID\<3\> \
        rd_ID\<2\> rd_ID\<1\> rd_ID\<0\> rd_IDEX\<4\> rd_IDEX\<3\> \
        rd_IDEX\<2\> rd_IDEX\<1\> rd_IDEX\<0\> wb_src_IDEX\<1\> \
        wb_src_IDEX\<0\> stall_ID mem_we_ID mem_re_ID mem_be_ID\<1\> \
        mem_be_ID\<0\> wb_src_ID\<1\> wb_src_ID\<0\> wb_we_ID \
        ALU_operation_ID\<3\> ALU_operation_ID\<2\> ALU_operation_ID\<1\> \
        ALU_operation_ID\<0\> is_branch_ID mem_load_unsigned_ID \
        reg_or_PC_ID is_jump_ID inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_instruction_decode_schematic
ends soc_no_opt_16may_top_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: instr_mem_wrap_address_width11
// View name: schematic
subckt instr_mem_wrap_address_width11 clk d_clk Address\<10\> Address\<9\> \
        Address\<8\> Address\<7\> Address\<6\> Address\<5\> Address\<4\> \
        Address\<3\> Address\<2\> Address\<1\> Address\<0\> \
        read_data\<31\> read_data\<30\> read_data\<29\> read_data\<28\> \
        read_data\<27\> read_data\<26\> read_data\<25\> read_data\<24\> \
        read_data\<23\> read_data\<22\> read_data\<21\> read_data\<20\> \
        read_data\<19\> read_data\<18\> read_data\<17\> read_data\<16\> \
        read_data\<15\> read_data\<14\> read_data\<13\> read_data\<12\> \
        read_data\<11\> read_data\<10\> read_data\<9\> read_data\<8\> \
        read_data\<7\> read_data\<6\> read_data\<5\> read_data\<4\> \
        read_data\<3\> read_data\<2\> read_data\<1\> read_data\<0\> \
        write_data_input\<31\> write_data_input\<30\> \
        write_data_input\<29\> write_data_input\<28\> \
        write_data_input\<27\> write_data_input\<26\> \
        write_data_input\<25\> write_data_input\<24\> \
        write_data_input\<23\> write_data_input\<22\> \
        write_data_input\<21\> write_data_input\<20\> \
        write_data_input\<19\> write_data_input\<18\> \
        write_data_input\<17\> write_data_input\<16\> \
        write_data_input\<15\> write_data_input\<14\> \
        write_data_input\<13\> write_data_input\<12\> \
        write_data_input\<11\> write_data_input\<10\> \
        write_data_input\<9\> write_data_input\<8\> write_data_input\<7\> \
        write_data_input\<6\> write_data_input\<5\> write_data_input\<4\> \
        write_data_input\<3\> write_data_input\<2\> write_data_input\<1\> \
        write_data_input\<0\> write_en reset_pulse_generator idle \
        reroute_write_en reroute_Address\<10\> reroute_Address\<9\> \
        reroute_Address\<8\> reroute_Address\<7\> reroute_Address\<6\> \
        reroute_Address\<5\> reroute_Address\<4\> reroute_Address\<3\> \
        reroute_Address\<2\> reroute_Address\<1\> reroute_Address\<0\> \
        reroute_write_data_input\<31\> reroute_write_data_input\<30\> \
        reroute_write_data_input\<29\> reroute_write_data_input\<28\> \
        reroute_write_data_input\<27\> reroute_write_data_input\<26\> \
        reroute_write_data_input\<25\> reroute_write_data_input\<24\> \
        reroute_write_data_input\<23\> reroute_write_data_input\<22\> \
        reroute_write_data_input\<21\> reroute_write_data_input\<20\> \
        reroute_write_data_input\<19\> reroute_write_data_input\<18\> \
        reroute_write_data_input\<17\> reroute_write_data_input\<16\> \
        reroute_write_data_input\<15\> reroute_write_data_input\<14\> \
        reroute_write_data_input\<13\> reroute_write_data_input\<12\> \
        reroute_write_data_input\<11\> reroute_write_data_input\<10\> \
        reroute_write_data_input\<9\> reroute_write_data_input\<8\> \
        reroute_write_data_input\<7\> reroute_write_data_input\<6\> \
        reroute_write_data_input\<5\> reroute_write_data_input\<4\> \
        reroute_write_data_input\<3\> reroute_write_data_input\<2\> \
        reroute_write_data_input\<1\> reroute_write_data_input\<0\> \
        reroute_read_data\<31\> reroute_read_data\<30\> \
        reroute_read_data\<29\> reroute_read_data\<28\> \
        reroute_read_data\<27\> reroute_read_data\<26\> \
        reroute_read_data\<25\> reroute_read_data\<24\> \
        reroute_read_data\<23\> reroute_read_data\<22\> \
        reroute_read_data\<21\> reroute_read_data\<20\> \
        reroute_read_data\<19\> reroute_read_data\<18\> \
        reroute_read_data\<17\> reroute_read_data\<16\> \
        reroute_read_data\<15\> reroute_read_data\<14\> \
        reroute_read_data\<13\> reroute_read_data\<12\> \
        reroute_read_data\<11\> reroute_read_data\<10\> \
        reroute_read_data\<9\> reroute_read_data\<8\> \
        reroute_read_data\<7\> reroute_read_data\<6\> \
        reroute_read_data\<5\> reroute_read_data\<4\> \
        reroute_read_data\<3\> reroute_read_data\<2\> \
        reroute_read_data\<1\> reroute_read_data\<0\> \
        reroute_reset_pulse_generator reroute_idle inh_gnd inh_gnds \
        inh_vdd inh_vdds
    Thru45 (reset_pulse_generator reroute_reset_pulse_generator) iprobe
    Thru44 (write_data_input\<0\> reroute_write_data_input\<0\>) iprobe
    Thru43 (write_data_input\<1\> reroute_write_data_input\<1\>) iprobe
    Thru42 (write_data_input\<2\> reroute_write_data_input\<2\>) iprobe
    Thru41 (write_data_input\<3\> reroute_write_data_input\<3\>) iprobe
    Thru40 (write_data_input\<4\> reroute_write_data_input\<4\>) iprobe
    Thru39 (write_data_input\<5\> reroute_write_data_input\<5\>) iprobe
    Thru38 (write_data_input\<6\> reroute_write_data_input\<6\>) iprobe
    Thru37 (write_data_input\<7\> reroute_write_data_input\<7\>) iprobe
    Thru36 (write_data_input\<8\> reroute_write_data_input\<8\>) iprobe
    Thru35 (write_data_input\<9\> reroute_write_data_input\<9\>) iprobe
    Thru34 (write_data_input\<10\> reroute_write_data_input\<10\>) iprobe
    Thru33 (write_data_input\<11\> reroute_write_data_input\<11\>) iprobe
    Thru32 (write_data_input\<12\> reroute_write_data_input\<12\>) iprobe
    Thru31 (write_data_input\<13\> reroute_write_data_input\<13\>) iprobe
    Thru30 (write_data_input\<14\> reroute_write_data_input\<14\>) iprobe
    Thru29 (write_data_input\<15\> reroute_write_data_input\<15\>) iprobe
    Thru28 (write_data_input\<16\> reroute_write_data_input\<16\>) iprobe
    Thru27 (write_data_input\<17\> reroute_write_data_input\<17\>) iprobe
    Thru26 (write_data_input\<18\> reroute_write_data_input\<18\>) iprobe
    Thru25 (write_data_input\<19\> reroute_write_data_input\<19\>) iprobe
    Thru24 (write_data_input\<20\> reroute_write_data_input\<20\>) iprobe
    Thru23 (write_data_input\<21\> reroute_write_data_input\<21\>) iprobe
    Thru22 (write_data_input\<22\> reroute_write_data_input\<22\>) iprobe
    Thru21 (write_data_input\<23\> reroute_write_data_input\<23\>) iprobe
    Thru20 (write_data_input\<24\> reroute_write_data_input\<24\>) iprobe
    Thru19 (write_data_input\<25\> reroute_write_data_input\<25\>) iprobe
    Thru18 (write_data_input\<26\> reroute_write_data_input\<26\>) iprobe
    Thru17 (write_data_input\<27\> reroute_write_data_input\<27\>) iprobe
    Thru16 (write_data_input\<28\> reroute_write_data_input\<28\>) iprobe
    Thru15 (write_data_input\<29\> reroute_write_data_input\<29\>) iprobe
    Thru14 (write_data_input\<30\> reroute_write_data_input\<30\>) iprobe
    Thru13 (write_data_input\<31\> reroute_write_data_input\<31\>) iprobe
    Thru1 (write_en reroute_write_en) iprobe
    Thru0 (reroute_idle idle) iprobe
    Thru12 (Address\<0\> reroute_Address\<0\>) iprobe
    Thru11 (Address\<1\> reroute_Address\<1\>) iprobe
    Thru10 (Address\<2\> reroute_Address\<2\>) iprobe
    Thru9 (Address\<3\> reroute_Address\<3\>) iprobe
    Thru8 (Address\<4\> reroute_Address\<4\>) iprobe
    Thru7 (Address\<5\> reroute_Address\<5\>) iprobe
    Thru6 (Address\<6\> reroute_Address\<6\>) iprobe
    Thru5 (Address\<7\> reroute_Address\<7\>) iprobe
    Thru4 (Address\<8\> reroute_Address\<8\>) iprobe
    Thru3 (Address\<9\> reroute_Address\<9\>) iprobe
    Thru2 (Address\<10\> reroute_Address\<10\>) iprobe
    U33 (n61 read_data\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U34 (n63 read_data\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (n59 read_data\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n57 read_data\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U30 (n55 read_data\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n53 read_data\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U28 (n51 read_data\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n49 read_data\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (n47 read_data\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n45 read_data\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U24 (n43 read_data\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U23 (n41 read_data\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n39 read_data\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (n37 read_data\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n35 read_data\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (n33 read_data\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U18 (n31 read_data\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n29 read_data\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U16 (n27 read_data\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n25 read_data\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (n23 read_data\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n21 read_data\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n19 read_data\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U11 (n17 read_data\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U10 (n15 read_data\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n13 read_data\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (n11 read_data\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n9 read_data\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (n7 read_data\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n5 read_data\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n3 read_data\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n1 read_data\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    read_data_reg_0_ (d_clk reroute_read_data\<0\> NeTt_355 n61 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_3_ (d_clk reroute_read_data\<3\> NeTt_356 n63 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_4_ (d_clk reroute_read_data\<4\> NeTt_357 n59 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_12_ (d_clk reroute_read_data\<12\> NeTt_358 n57 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_13_ (d_clk reroute_read_data\<13\> NeTt_359 n55 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_15_ (d_clk reroute_read_data\<15\> NeTt_360 n53 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_17_ (d_clk reroute_read_data\<17\> NeTt_361 n51 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_18_ (d_clk reroute_read_data\<18\> NeTt_362 n49 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_20_ (d_clk reroute_read_data\<20\> NeTt_363 n47 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_22_ (d_clk reroute_read_data\<22\> NeTt_364 n45 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_23_ (d_clk reroute_read_data\<23\> NeTt_365 n43 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_6_ (d_clk reroute_read_data\<6\> NeTt_366 n41 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_7_ (d_clk reroute_read_data\<7\> NeTt_367 n39 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_14_ (d_clk reroute_read_data\<14\> NeTt_368 n37 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_16_ (d_clk reroute_read_data\<16\> NeTt_369 n35 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_21_ (d_clk reroute_read_data\<21\> NeTt_370 n33 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_2_ (d_clk reroute_read_data\<2\> NeTt_371 n31 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_28_ (d_clk reroute_read_data\<28\> NeTt_372 n29 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_8_ (d_clk reroute_read_data\<8\> NeTt_373 n27 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_9_ (d_clk reroute_read_data\<9\> NeTt_374 n25 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_19_ (d_clk reroute_read_data\<19\> NeTt_375 n23 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_1_ (d_clk reroute_read_data\<1\> NeTt_376 n21 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_27_ (d_clk reroute_read_data\<27\> NeTt_377 n19 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_10_ (d_clk reroute_read_data\<10\> NeTt_378 n17 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_31_ (d_clk reroute_read_data\<31\> NeTt_379 n15 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_5_ (d_clk reroute_read_data\<5\> NeTt_380 n13 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_26_ (d_clk reroute_read_data\<26\> NeTt_381 n11 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_30_ (d_clk reroute_read_data\<30\> NeTt_382 n9 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_29_ (d_clk reroute_read_data\<29\> NeTt_383 n7 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_25_ (d_clk reroute_read_data\<25\> NeTt_384 n5 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_11_ (d_clk reroute_read_data\<11\> NeTt_385 n3 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_24_ (d_clk reroute_read_data\<24\> NeTt_386 n1 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
ends instr_mem_wrap_address_width11
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: data_mem_wrap_address_width11
// View name: schematic
subckt data_mem_wrap_address_width11 clk d_clk be\<1\> be\<0\> \
        Address\<10\> Address\<9\> Address\<8\> Address\<7\> Address\<6\> \
        Address\<5\> Address\<4\> Address\<3\> Address\<2\> Address\<1\> \
        Address\<0\> read_data\<31\> read_data\<30\> read_data\<29\> \
        read_data\<28\> read_data\<27\> read_data\<26\> read_data\<25\> \
        read_data\<24\> read_data\<23\> read_data\<22\> read_data\<21\> \
        read_data\<20\> read_data\<19\> read_data\<18\> read_data\<17\> \
        read_data\<16\> read_data\<15\> read_data\<14\> read_data\<13\> \
        read_data\<12\> read_data\<11\> read_data\<10\> read_data\<9\> \
        read_data\<8\> read_data\<7\> read_data\<6\> read_data\<5\> \
        read_data\<4\> read_data\<3\> read_data\<2\> read_data\<1\> \
        read_data\<0\> write_data_input\<31\> write_data_input\<30\> \
        write_data_input\<29\> write_data_input\<28\> \
        write_data_input\<27\> write_data_input\<26\> \
        write_data_input\<25\> write_data_input\<24\> \
        write_data_input\<23\> write_data_input\<22\> \
        write_data_input\<21\> write_data_input\<20\> \
        write_data_input\<19\> write_data_input\<18\> \
        write_data_input\<17\> write_data_input\<16\> \
        write_data_input\<15\> write_data_input\<14\> \
        write_data_input\<13\> write_data_input\<12\> \
        write_data_input\<11\> write_data_input\<10\> \
        write_data_input\<9\> write_data_input\<8\> write_data_input\<7\> \
        write_data_input\<6\> write_data_input\<5\> write_data_input\<4\> \
        write_data_input\<3\> write_data_input\<2\> write_data_input\<1\> \
        write_data_input\<0\> write_en reset_pulse_generator idle \
        reroute_write_en reroute_Address\<10\> reroute_Address\<9\> \
        reroute_Address\<8\> reroute_Address\<7\> reroute_Address\<6\> \
        reroute_Address\<5\> reroute_Address\<4\> reroute_Address\<3\> \
        reroute_Address\<2\> reroute_Address\<1\> reroute_Address\<0\> \
        reroute_write_data_input\<31\> reroute_write_data_input\<30\> \
        reroute_write_data_input\<29\> reroute_write_data_input\<28\> \
        reroute_write_data_input\<27\> reroute_write_data_input\<26\> \
        reroute_write_data_input\<25\> reroute_write_data_input\<24\> \
        reroute_write_data_input\<23\> reroute_write_data_input\<22\> \
        reroute_write_data_input\<21\> reroute_write_data_input\<20\> \
        reroute_write_data_input\<19\> reroute_write_data_input\<18\> \
        reroute_write_data_input\<17\> reroute_write_data_input\<16\> \
        reroute_write_data_input\<15\> reroute_write_data_input\<14\> \
        reroute_write_data_input\<13\> reroute_write_data_input\<12\> \
        reroute_write_data_input\<11\> reroute_write_data_input\<10\> \
        reroute_write_data_input\<9\> reroute_write_data_input\<8\> \
        reroute_write_data_input\<7\> reroute_write_data_input\<6\> \
        reroute_write_data_input\<5\> reroute_write_data_input\<4\> \
        reroute_write_data_input\<3\> reroute_write_data_input\<2\> \
        reroute_write_data_input\<1\> reroute_write_data_input\<0\> \
        reroute_read_data\<31\> reroute_read_data\<30\> \
        reroute_read_data\<29\> reroute_read_data\<28\> \
        reroute_read_data\<27\> reroute_read_data\<26\> \
        reroute_read_data\<25\> reroute_read_data\<24\> \
        reroute_read_data\<23\> reroute_read_data\<22\> \
        reroute_read_data\<21\> reroute_read_data\<20\> \
        reroute_read_data\<19\> reroute_read_data\<18\> \
        reroute_read_data\<17\> reroute_read_data\<16\> \
        reroute_read_data\<15\> reroute_read_data\<14\> \
        reroute_read_data\<13\> reroute_read_data\<12\> \
        reroute_read_data\<11\> reroute_read_data\<10\> \
        reroute_read_data\<9\> reroute_read_data\<8\> \
        reroute_read_data\<7\> reroute_read_data\<6\> \
        reroute_read_data\<5\> reroute_read_data\<4\> \
        reroute_read_data\<3\> reroute_read_data\<2\> \
        reroute_read_data\<1\> reroute_read_data\<0\> reroute_be\<1\> \
        reroute_be\<0\> reroute_reset_pulse_generator reroute_idle inh_gnd \
        inh_gnds inh_vdd inh_vdds
    Thru46 (be\<0\> reroute_be\<0\>) iprobe
    Thru45 (be\<1\> reroute_be\<1\>) iprobe
    Thru47 (reset_pulse_generator reroute_reset_pulse_generator) iprobe
    Thru44 (write_data_input\<0\> reroute_write_data_input\<0\>) iprobe
    Thru43 (write_data_input\<1\> reroute_write_data_input\<1\>) iprobe
    Thru42 (write_data_input\<2\> reroute_write_data_input\<2\>) iprobe
    Thru41 (write_data_input\<3\> reroute_write_data_input\<3\>) iprobe
    Thru40 (write_data_input\<4\> reroute_write_data_input\<4\>) iprobe
    Thru39 (write_data_input\<5\> reroute_write_data_input\<5\>) iprobe
    Thru38 (write_data_input\<6\> reroute_write_data_input\<6\>) iprobe
    Thru37 (write_data_input\<7\> reroute_write_data_input\<7\>) iprobe
    Thru36 (write_data_input\<8\> reroute_write_data_input\<8\>) iprobe
    Thru35 (write_data_input\<9\> reroute_write_data_input\<9\>) iprobe
    Thru34 (write_data_input\<10\> reroute_write_data_input\<10\>) iprobe
    Thru33 (write_data_input\<11\> reroute_write_data_input\<11\>) iprobe
    Thru32 (write_data_input\<12\> reroute_write_data_input\<12\>) iprobe
    Thru31 (write_data_input\<13\> reroute_write_data_input\<13\>) iprobe
    Thru30 (write_data_input\<14\> reroute_write_data_input\<14\>) iprobe
    Thru29 (write_data_input\<15\> reroute_write_data_input\<15\>) iprobe
    Thru28 (write_data_input\<16\> reroute_write_data_input\<16\>) iprobe
    Thru27 (write_data_input\<17\> reroute_write_data_input\<17\>) iprobe
    Thru26 (write_data_input\<18\> reroute_write_data_input\<18\>) iprobe
    Thru25 (write_data_input\<19\> reroute_write_data_input\<19\>) iprobe
    Thru24 (write_data_input\<20\> reroute_write_data_input\<20\>) iprobe
    Thru23 (write_data_input\<21\> reroute_write_data_input\<21\>) iprobe
    Thru22 (write_data_input\<22\> reroute_write_data_input\<22\>) iprobe
    Thru21 (write_data_input\<23\> reroute_write_data_input\<23\>) iprobe
    Thru20 (write_data_input\<24\> reroute_write_data_input\<24\>) iprobe
    Thru19 (write_data_input\<25\> reroute_write_data_input\<25\>) iprobe
    Thru18 (write_data_input\<26\> reroute_write_data_input\<26\>) iprobe
    Thru17 (write_data_input\<27\> reroute_write_data_input\<27\>) iprobe
    Thru16 (write_data_input\<28\> reroute_write_data_input\<28\>) iprobe
    Thru15 (write_data_input\<29\> reroute_write_data_input\<29\>) iprobe
    Thru14 (write_data_input\<30\> reroute_write_data_input\<30\>) iprobe
    Thru13 (write_data_input\<31\> reroute_write_data_input\<31\>) iprobe
    Thru1 (write_en reroute_write_en) iprobe
    Thru0 (reroute_idle idle) iprobe
    Thru12 (Address\<0\> reroute_Address\<0\>) iprobe
    Thru11 (Address\<1\> reroute_Address\<1\>) iprobe
    Thru10 (Address\<2\> reroute_Address\<2\>) iprobe
    Thru9 (Address\<3\> reroute_Address\<3\>) iprobe
    Thru8 (Address\<4\> reroute_Address\<4\>) iprobe
    Thru7 (Address\<5\> reroute_Address\<5\>) iprobe
    Thru6 (Address\<6\> reroute_Address\<6\>) iprobe
    Thru5 (Address\<7\> reroute_Address\<7\>) iprobe
    Thru4 (Address\<8\> reroute_Address\<8\>) iprobe
    Thru3 (Address\<9\> reroute_Address\<9\>) iprobe
    Thru2 (Address\<10\> reroute_Address\<10\>) iprobe
    read_data_reg_0_ (d_clk reroute_read_data\<0\> read_data\<0\> NeTt_334 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_1_ (d_clk reroute_read_data\<1\> read_data\<1\> NeTt_335 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_2_ (d_clk reroute_read_data\<2\> read_data\<2\> NeTt_336 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_3_ (d_clk reroute_read_data\<3\> read_data\<3\> NeTt_337 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_4_ (d_clk reroute_read_data\<4\> read_data\<4\> NeTt_338 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_5_ (d_clk reroute_read_data\<5\> read_data\<5\> NeTt_339 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_6_ (d_clk reroute_read_data\<6\> read_data\<6\> NeTt_340 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_7_ (d_clk reroute_read_data\<7\> read_data\<7\> NeTt_341 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_8_ (d_clk reroute_read_data\<8\> read_data\<8\> NeTt_342 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_9_ (d_clk reroute_read_data\<9\> read_data\<9\> NeTt_343 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_10_ (d_clk reroute_read_data\<10\> read_data\<10\> \
        NeTt_344 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_11_ (d_clk reroute_read_data\<11\> read_data\<11\> \
        NeTt_345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_12_ (d_clk reroute_read_data\<12\> read_data\<12\> \
        NeTt_346 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_13_ (d_clk reroute_read_data\<13\> read_data\<13\> \
        NeTt_347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_14_ (d_clk reroute_read_data\<14\> read_data\<14\> \
        NeTt_348 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_15_ (d_clk reroute_read_data\<15\> read_data\<15\> \
        NeTt_349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_16_ (d_clk reroute_read_data\<16\> read_data\<16\> \
        NeTt_350 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_17_ (d_clk reroute_read_data\<17\> read_data\<17\> \
        NeTt_351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_18_ (d_clk reroute_read_data\<18\> read_data\<18\> \
        NeTt_352 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_19_ (d_clk reroute_read_data\<19\> read_data\<19\> \
        NeTt_353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_20_ (d_clk reroute_read_data\<20\> read_data\<20\> \
        NeTt_354 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_21_ (d_clk reroute_read_data\<21\> read_data\<21\> \
        NeTt_355 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_22_ (d_clk reroute_read_data\<22\> read_data\<22\> \
        NeTt_356 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_23_ (d_clk reroute_read_data\<23\> read_data\<23\> \
        NeTt_357 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_24_ (d_clk reroute_read_data\<24\> read_data\<24\> \
        NeTt_358 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_25_ (d_clk reroute_read_data\<25\> read_data\<25\> \
        NeTt_359 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_26_ (d_clk reroute_read_data\<26\> read_data\<26\> \
        NeTt_360 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_27_ (d_clk reroute_read_data\<27\> read_data\<27\> \
        NeTt_361 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_28_ (d_clk reroute_read_data\<28\> read_data\<28\> \
        NeTt_362 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_29_ (d_clk reroute_read_data\<29\> read_data\<29\> \
        NeTt_363 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_30_ (d_clk reroute_read_data\<30\> read_data\<30\> \
        NeTt_364 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    read_data_reg_31_ (d_clk reroute_read_data\<31\> read_data\<31\> \
        NeTt_365 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
ends data_mem_wrap_address_width11
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: timer_DW01_inc_0
// View name: schematic
subckt timer_DW01_inc_0_schematic A\<63\> A\<62\> A\<61\> A\<60\> A\<59\> \
        A\<58\> A\<57\> A\<56\> A\<55\> A\<54\> A\<53\> A\<52\> A\<51\> \
        A\<50\> A\<49\> A\<48\> A\<47\> A\<46\> A\<45\> A\<44\> A\<43\> \
        A\<42\> A\<41\> A\<40\> A\<39\> A\<38\> A\<37\> A\<36\> A\<35\> \
        A\<34\> A\<33\> A\<32\> A\<31\> A\<30\> A\<29\> A\<28\> A\<27\> \
        A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> A\<20\> A\<19\> \
        A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> A\<12\> A\<11\> \
        A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> A\<3\> A\<2\> \
        A\<1\> A\<0\> SUM\<63\> SUM\<62\> SUM\<61\> SUM\<60\> SUM\<59\> \
        SUM\<58\> SUM\<57\> SUM\<56\> SUM\<55\> SUM\<54\> SUM\<53\> \
        SUM\<52\> SUM\<51\> SUM\<50\> SUM\<49\> SUM\<48\> SUM\<47\> \
        SUM\<46\> SUM\<45\> SUM\<44\> SUM\<43\> SUM\<42\> SUM\<41\> \
        SUM\<40\> SUM\<39\> SUM\<38\> SUM\<37\> SUM\<36\> SUM\<35\> \
        SUM\<34\> SUM\<33\> SUM\<32\> SUM\<31\> SUM\<30\> SUM\<29\> \
        SUM\<28\> SUM\<27\> SUM\<26\> SUM\<25\> SUM\<24\> SUM\<23\> \
        SUM\<22\> SUM\<21\> SUM\<20\> SUM\<19\> SUM\<18\> SUM\<17\> \
        SUM\<16\> SUM\<15\> SUM\<14\> SUM\<13\> SUM\<12\> SUM\<11\> \
        SUM\<10\> SUM\<9\> SUM\<8\> SUM\<7\> SUM\<6\> SUM\<5\> SUM\<4\> \
        SUM\<3\> SUM\<2\> SUM\<1\> SUM\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U38 (n228 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n266 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U90 (n190 n90 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U123 (A\<62\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U58 (n139 n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U122 (A\<61\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U34 (n146 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n156 n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n163 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n170 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (n177 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n184 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n194 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (n201 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n208 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n215 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (n222 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n232 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n239 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n246 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U92 (A\<1\> n92 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U91 (A\<0\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U121 (A\<59\> n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n34 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U120 (A\<57\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U55 (n54 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U119 (A\<55\> n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U118 (A\<53\> n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U33 (n32 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U117 (A\<51\> n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U53 (n52 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U116 (A\<49\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n14 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U115 (A\<47\> n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n30 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U114 (A\<45\> n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U51 (n50 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U113 (A\<43\> n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n12 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U112 (A\<41\> n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n28 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U111 (A\<39\> n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n48 n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U110 (A\<37\> n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U11 (n10 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U109 (A\<35\> n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n26 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U108 (A\<33\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U47 (n46 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (n152 n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n38 n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U89 (n135 n89 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n260 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n270 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n277 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (n284 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (n291 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n298 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n307 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n314 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n321 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n328 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n126 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (n337 n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n331 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n324 n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (n317 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n310 n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n301 n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n294 n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U93 (A\<3\> n93 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U107 (A\<31\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n253 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U106 (A\<29\> n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n24 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U105 (A\<27\> n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U45 (n44 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U104 (A\<25\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (n7 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U103 (A\<23\> n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U23 (n22 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U102 (A\<21\> n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U43 (n42 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U101 (A\<19\> n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U100 (A\<17\> n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (n20 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U99 (A\<15\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n40 n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U98 (A\<13\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n3 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U97 (A\<11\> n97 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U96 (A\<9\> n96 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n36 n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U95 (A\<7\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n287 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U68 (n280 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n273 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (n263 n70 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (n256 n71 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U72 (n249 n72 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U73 (n242 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U74 (n235 n74 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (n225 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (n218 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n211 n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n204 n78 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U79 (n197 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U80 (n187 n80 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U81 (n180 n81 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (n173 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U83 (n166 n83 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U84 (n159 n84 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U85 (n149 n85 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n144 n86 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U87 (n138 n87 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n132 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (n56 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U88 (n129 n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U94 (A\<5\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U403 (n341 A\<2\> n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U206 (n38 A\<3\> n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U351 (n92 A\<0\> n302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U349 (n302 n303 SUM\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U350 (n91 A\<1\> n303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U301 (n265 A\<2\> n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U300 (n59 n264 SUM\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (n189 A\<4\> n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n90 n188 SUM\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n123 n139 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n140 n141 SUM\<62\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n58 A\<62\> n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n145 A\<60\> n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n121 n34 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n153 n154 SUM\<59\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (A\<59\> n35 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n155 A\<58\> n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n120 n54 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n160 n161 SUM\<57\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (A\<57\> n55 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n162 A\<56\> n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n119 n16 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n167 n168 SUM\<55\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (A\<55\> n17 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n169 A\<54\> n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n118 n32 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n174 n175 SUM\<53\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (A\<53\> n33 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n176 A\<52\> n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n117 n52 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n181 n182 SUM\<51\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (A\<51\> n53 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n183 A\<50\> n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (n116 n14 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n191 n192 SUM\<49\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (A\<49\> n15 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n193 A\<48\> n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n115 n30 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n198 n199 SUM\<47\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (A\<47\> n31 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n200 A\<46\> n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n114 n50 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n205 n206 SUM\<45\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (A\<45\> n51 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n207 A\<44\> n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n113 n12 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n212 n213 SUM\<43\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U235 (A\<43\> n13 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n214 A\<42\> n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n112 n28 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (n219 n220 SUM\<41\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (A\<41\> n29 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n221 A\<40\> n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U257 (n111 n48 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U255 (n229 n230 SUM\<39\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U256 (A\<39\> n49 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U258 (n231 A\<38\> n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U266 (n110 n10 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n236 n237 SUM\<37\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U265 (A\<37\> n11 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (n238 A\<36\> n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (n109 n26 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n243 n244 SUM\<35\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U274 (A\<35\> n27 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n245 A\<34\> n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U284 (n108 n46 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U282 (n250 n251 SUM\<33\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U283 (A\<33\> n47 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U285 (n252 A\<32\> n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U303 (A\<1\> A\<0\> n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (A\<62\> n139 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n34 A\<59\> n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n54 A\<57\> n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n16 A\<55\> n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n32 A\<53\> n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n52 A\<51\> n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U202 (n14 A\<49\> n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n30 A\<47\> n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (n50 A\<45\> n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (n12 A\<43\> n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (n28 A\<41\> n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (n48 A\<39\> n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U263 (n10 A\<37\> n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n26 A\<35\> n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (n46 A\<33\> n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U401 (n340 A\<4\> n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n56 A\<5\> n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n93 n38 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U253 (A\<3\> n39 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (n226 n227 SUM\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n134 A\<6\> n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n89 n133 SUM\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (n107 n9 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U291 (n257 n258 SUM\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U292 (A\<31\> n253 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U306 (n106 n24 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U304 (n267 n268 SUM\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U305 (n25 A\<29\> n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U307 (n269 A\<28\> n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U315 (n105 n44 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U313 (n274 n275 SUM\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U314 (A\<27\> n45 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U316 (n276 A\<26\> n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U324 (n104 n7 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U322 (n281 n282 SUM\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U323 (A\<25\> n8 n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (n283 A\<24\> n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (n103 n22 n288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U331 (n288 n289 SUM\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U332 (A\<23\> n23 n289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U334 (n290 A\<22\> n284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U342 (n102 n42 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U340 (n295 n296 SUM\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U341 (A\<21\> n43 n296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U343 (n297 A\<20\> n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U354 (n101 n5 n304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U352 (n304 n305 SUM\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U353 (A\<19\> n6 n305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U355 (n306 A\<18\> n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U363 (n100 n20 n311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U361 (n311 n312 SUM\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U362 (A\<17\> n21 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U364 (n313 A\<16\> n307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U372 (n99 n40 n318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U370 (n318 n319 SUM\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U371 (A\<15\> n41 n319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U373 (n320 A\<14\> n314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U381 (n98 n3 n325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U379 (n325 n326 SUM\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U380 (A\<13\> n4 n326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U382 (n327 A\<12\> n321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U390 (n97 n1 n332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U388 (n332 n333 SUM\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U389 (A\<11\> n2 n333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U391 (n334 A\<10\> n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n96 n36 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n124 n125 SUM\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (A\<9\> n37 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U397 (n338 A\<8\> n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n95 n18 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n130 n131 SUM\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (A\<7\> n19 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U394 (n336 A\<10\> n335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U393 (n60 n335 SUM\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U385 (n330 A\<12\> n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U384 (n61 n329 SUM\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U376 (n323 A\<14\> n322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U375 (n62 n322 SUM\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U367 (n316 A\<16\> n315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U366 (n63 n315 SUM\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U358 (n309 A\<18\> n308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U357 (n64 n308 SUM\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U346 (n300 A\<20\> n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U345 (n65 n299 SUM\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (n293 A\<22\> n292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U336 (n66 n292 SUM\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U294 (n259 A\<30\> n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U290 (A\<31\> n9 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U299 (n24 A\<29\> n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U312 (n44 A\<27\> n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U321 (n7 A\<25\> n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U330 (n22 A\<23\> n286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U339 (n42 A\<21\> n293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U348 (n5 A\<19\> n300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U360 (n20 A\<17\> n309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U369 (n40 A\<15\> n316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U378 (n3 A\<13\> n323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U387 (n1 A\<11\> n330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U396 (n36 A\<9\> n336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U328 (n286 A\<24\> n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (n67 n285 SUM\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U319 (n279 A\<26\> n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U318 (n68 n278 SUM\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U310 (n272 A\<28\> n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U309 (n69 n271 SUM\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U297 (n262 A\<30\> n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U296 (n70 n261 SUM\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U288 (n255 A\<32\> n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U287 (n71 n254 SUM\<32\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (n248 A\<34\> n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U278 (n72 n247 SUM\<34\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U270 (n241 A\<36\> n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n73 n240 SUM\<36\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (n234 A\<38\> n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n74 n233 SUM\<38\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (n224 A\<40\> n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U248 (n75 n223 SUM\<40\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n217 A\<42\> n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n76 n216 SUM\<42\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n210 A\<44\> n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U230 (n77 n209 SUM\<44\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n203 A\<46\> n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (n78 n202 SUM\<46\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n196 A\<48\> n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (n79 n195 SUM\<48\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n186 A\<50\> n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (n80 n185 SUM\<50\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n179 A\<52\> n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n81 n178 SUM\<52\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n172 A\<54\> n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n82 n171 SUM\<54\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n165 A\<56\> n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n83 n164 SUM\<56\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n158 A\<58\> n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n84 n157 SUM\<58\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n148 A\<60\> n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n85 n147 SUM\<60\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (A\<61\> n142 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n86 n143 SUM\<61\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n87 n136 SUM\<63\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (A\<63\> n137 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U399 (n339 A\<6\> n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n18 A\<7\> n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n94 n56 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (A\<5\> n57 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n150 n151 SUM\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n128 A\<8\> n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n88 n127 SUM\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U404 (n91 n92 n341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U302 (n265 A\<2\> n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U205 (n189 A\<4\> n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U145 (n142 n122 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U150 (n121 n35 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U162 (n120 n55 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U171 (n119 n17 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (n118 n33 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U189 (n117 n53 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U198 (n116 n15 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U211 (n115 n31 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U220 (n114 n51 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U229 (n113 n13 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U238 (n112 n29 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U247 (n111 n49 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U259 (n110 n11 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U268 (n109 n27 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U277 (n108 n47 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U402 (n93 n39 n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U136 (n134 A\<6\> n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U308 (n105 n45 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U317 (n104 n8 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U326 (n103 n23 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U335 (n102 n43 n290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U344 (n101 n6 n297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U356 (n100 n21 n306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U365 (n99 n41 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U374 (n98 n4 n320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U383 (n97 n2 n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U392 (n96 n37 n334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U398 (n95 n19 n338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U395 (n336 A\<10\> n337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U386 (n330 A\<12\> n331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U377 (n323 A\<14\> n324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U368 (n316 A\<16\> n317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U359 (n309 A\<18\> n310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U347 (n300 A\<20\> n301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U338 (n293 A\<22\> n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U295 (n106 n25 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U286 (n253 n107 n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U329 (n286 A\<24\> n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U320 (n279 A\<26\> n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U311 (n272 A\<28\> n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U298 (n262 A\<30\> n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U289 (n255 A\<32\> n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U280 (n248 A\<34\> n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U271 (n241 A\<36\> n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n234 A\<38\> n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U250 (n224 A\<40\> n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U241 (n217 A\<42\> n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U232 (n210 A\<44\> n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U223 (n203 A\<46\> n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U214 (n196 A\<48\> n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U201 (n186 A\<50\> n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U192 (n179 A\<52\> n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U183 (n172 A\<54\> n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U174 (n165 A\<56\> n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U165 (n158 A\<58\> n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U153 (n148 A\<60\> n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n142 A\<61\> n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U140 (n137 A\<63\> n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U400 (n94 n57 n339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U129 (n128 A\<8\> n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends timer_DW01_inc_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: timer
// View name: schematic
subckt timer_schematic clk timer\<63\> timer\<62\> timer\<61\> timer\<60\> \
        timer\<59\> timer\<58\> timer\<57\> timer\<56\> timer\<55\> \
        timer\<54\> timer\<53\> timer\<52\> timer\<51\> timer\<50\> \
        timer\<49\> timer\<48\> timer\<47\> timer\<46\> timer\<45\> \
        timer\<44\> timer\<43\> timer\<42\> timer\<41\> timer\<40\> \
        timer\<39\> timer\<38\> timer\<37\> timer\<36\> timer\<35\> \
        timer\<34\> timer\<33\> timer\<32\> timer\<31\> timer\<30\> \
        timer\<29\> timer\<28\> timer\<27\> timer\<26\> timer\<25\> \
        timer\<24\> timer\<23\> timer\<22\> timer\<21\> timer\<20\> \
        timer\<19\> timer\<18\> timer\<17\> timer\<16\> timer\<15\> \
        timer\<14\> timer\<13\> timer\<12\> timer\<11\> timer\<10\> \
        timer\<9\> timer\<8\> timer\<7\> timer\<6\> timer\<5\> timer\<4\> \
        timer\<3\> timer\<2\> timer\<1\> timer\<0\> nreset inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U22 (n38 timer\<34\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U195 (N6 n194 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n8 timer\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U194 (N5 n193 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (n9 timer\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U193 (N8 n192 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n6 timer\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U192 (N7 n191 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n7 timer\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U191 (N10 n190 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n4 timer\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U190 (N9 n189 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n5 timer\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U189 (N65 n188 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n63 timer\<63\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U188 (N64 n187 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (n58 timer\<62\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U187 (N63 n186 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n65 timer\<61\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U186 (N62 n185 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n59 timer\<60\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U185 (N61 n184 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U65 (n60 timer\<59\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U184 (N60 n183 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (n61 timer\<58\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U183 (N59 n182 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U64 (n62 timer\<57\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U182 (N58 n181 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n52 timer\<56\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U181 (N57 n180 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U63 (n53 timer\<55\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U180 (N56 n179 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n54 timer\<54\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U179 (N55 n178 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n55 timer\<53\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U178 (N54 n177 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n56 timer\<52\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U177 (N53 n176 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (n57 timer\<51\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U176 (N52 n175 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (n46 timer\<50\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U175 (N51 n174 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (n47 timer\<49\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U174 (N50 n173 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n48 timer\<48\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U173 (N49 n172 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (n49 timer\<47\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U172 (N48 n171 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n50 timer\<46\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U171 (N47 n170 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (n51 timer\<45\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U170 (N46 n169 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n40 timer\<44\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U169 (N45 n168 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (n41 timer\<43\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U168 (N44 n167 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (n42 timer\<42\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U167 (N43 n166 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (n43 timer\<41\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U166 (N42 n165 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n44 timer\<40\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U165 (N41 n164 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (n45 timer\<39\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U164 (N40 n163 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n34 timer\<38\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U163 (N39 n162 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n35 timer\<37\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U162 (N38 n161 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n36 timer\<36\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U161 (N37 n160 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U53 (n37 timer\<35\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U160 (N35 n158 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (n39 timer\<33\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U159 (N34 n157 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n28 timer\<32\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U158 (N33 n156 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (n29 timer\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U157 (N32 n155 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n30 timer\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U156 (N31 n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (n31 timer\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U155 (N30 n153 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n32 timer\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U133 (nreset n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (nreset n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U132 (n3 timer\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U154 (N29 n152 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (n33 timer\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U153 (N28 n151 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n22 timer\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U152 (N27 n150 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (n23 timer\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U151 (N26 n149 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n24 timer\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U150 (N25 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n25 timer\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U149 (N24 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n26 timer\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U148 (N23 n146 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n27 timer\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U147 (N22 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n16 timer\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U146 (N21 n144 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n17 timer\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U145 (N20 n143 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n18 timer\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U144 (N19 n142 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n19 timer\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U143 (N18 n141 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n20 timer\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U142 (N17 n140 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (n21 timer\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U141 (N16 n139 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n10 timer\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U140 (N15 n138 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (n11 timer\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U139 (N14 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n12 timer\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U10 (n14 timer\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U136 (N12 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U138 (N13 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n13 timer\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U137 (N11 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n15 timer\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U135 (N3 n133 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n2 timer\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U134 (N4 n132 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n1 timer\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    timer_unsigned_reg_34_ (clk n159 NeTt_476 n38 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_4_ (clk N70 NeTt_477 n8 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_3_ (clk N69 NeTt_478 n9 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_6_ (clk N72 NeTt_479 n6 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_5_ (clk N71 NeTt_480 n7 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_8_ (clk N74 NeTt_481 n4 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_7_ (clk N73 NeTt_482 n5 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_63_ (clk N129 NeTt_483 n63 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_62_ (clk N128 NeTt_484 n58 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_61_ (clk N127 NeTt_485 n65 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_60_ (clk N126 NeTt_486 n59 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_59_ (clk N125 NeTt_487 n60 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_58_ (clk N124 NeTt_488 n61 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_57_ (clk N123 NeTt_489 n62 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_56_ (clk N122 NeTt_490 n52 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_55_ (clk N121 NeTt_491 n53 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_54_ (clk N120 NeTt_492 n54 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_53_ (clk N119 NeTt_493 n55 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_52_ (clk N118 NeTt_494 n56 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_51_ (clk N117 NeTt_495 n57 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_50_ (clk N116 NeTt_496 n46 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_49_ (clk N115 NeTt_497 n47 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_48_ (clk N114 NeTt_498 n48 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_47_ (clk N113 NeTt_499 n49 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_46_ (clk N112 NeTt_500 n50 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_45_ (clk N111 NeTt_501 n51 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_44_ (clk N110 NeTt_502 n40 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_43_ (clk N109 NeTt_503 n41 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_42_ (clk N108 NeTt_504 n42 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_41_ (clk N107 NeTt_505 n43 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_40_ (clk N106 NeTt_506 n44 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_39_ (clk N105 NeTt_507 n45 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_38_ (clk N104 NeTt_508 n34 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_37_ (clk N103 NeTt_509 n35 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_36_ (clk N102 NeTt_510 n36 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_35_ (clk N101 NeTt_511 n37 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_33_ (clk N99 NeTt_512 n39 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_32_ (clk N98 NeTt_513 n28 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_31_ (clk N97 NeTt_514 n29 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_30_ (clk N96 NeTt_515 n30 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_29_ (clk N95 NeTt_516 n31 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_28_ (clk N94 NeTt_517 n32 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_0_ (clk N66 NeTt_518 n3 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_27_ (clk N93 NeTt_519 n33 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_26_ (clk N92 NeTt_520 n22 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_25_ (clk N91 NeTt_521 n23 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_24_ (clk N90 NeTt_522 n24 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_23_ (clk N89 NeTt_523 n25 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_22_ (clk N88 NeTt_524 n26 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_21_ (clk N87 NeTt_525 n27 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_20_ (clk N86 NeTt_526 n16 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_19_ (clk N85 NeTt_527 n17 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_18_ (clk N84 NeTt_528 n18 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_17_ (clk N83 NeTt_529 n19 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_16_ (clk N82 NeTt_530 n20 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_15_ (clk N81 NeTt_531 n21 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_14_ (clk N80 NeTt_532 n10 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_13_ (clk N79 NeTt_533 n11 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_12_ (clk N78 NeTt_534 n12 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_10_ (clk N76 NeTt_535 n14 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_11_ (clk N77 NeTt_536 n13 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_9_ (clk N75 NeTt_537 n15 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_1_ (clk N67 NeTt_538 n2 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    timer_unsigned_reg_2_ (clk N68 NeTt_539 n1 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U97 (n194 n131 N70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U98 (n193 n131 N69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U95 (n192 n131 N72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U96 (n191 n67 N71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (n190 n67 N74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U94 (n189 n67 N73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U102 (n188 n67 N129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U103 (n187 n131 N128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U104 (n186 n67 N127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (n185 n131 N126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n184 n67 N125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U107 (n183 n131 N124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U108 (n182 n67 N123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U109 (n181 n67 N122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U110 (n180 n131 N121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U111 (n179 n67 N120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (n178 n67 N119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (n177 n131 N118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n176 n131 N117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U115 (n175 n67 N116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U116 (n174 n67 N115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U117 (n173 n67 N114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U118 (n172 n131 N113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U119 (n171 n67 N112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (n170 n67 N111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U121 (n169 n131 N110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U122 (n168 n131 N109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U123 (n167 n67 N108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U124 (n166 n131 N107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U125 (n165 n67 N106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U126 (n164 n131 N105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U127 (n163 n131 N104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U128 (n162 n67 N103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U129 (n161 n131 N102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U130 (n160 n67 N101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U68 (n67 n158 N99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U69 (n157 n131 N98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (n156 n131 N97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (n155 n67 N96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n154 n67 N95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U73 (n153 n131 N94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U101 (timer\<0\> n131 N66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U74 (n152 n131 N93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U75 (n151 n67 N92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U76 (n150 n131 N91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U77 (n149 n131 N90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (n148 n67 N89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U79 (n147 n67 N88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U80 (n146 n131 N87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U81 (n145 n67 N86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U82 (n144 n67 N85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U83 (n143 n131 N84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (n142 n131 N83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (n141 n131 N82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U86 (n140 n131 N81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U87 (n139 n67 N80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U88 (n138 n67 N79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U89 (n137 n67 N78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (n134 n67 N76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U90 (n136 n131 N77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (n135 n131 N75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U100 (n133 n131 N67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n132 n131 N68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    add_28 (timer\<63\> timer\<62\> timer\<61\> timer\<60\> timer\<59\> \
        timer\<58\> timer\<57\> timer\<56\> timer\<55\> timer\<54\> \
        timer\<53\> timer\<52\> timer\<51\> timer\<50\> timer\<49\> \
        timer\<48\> timer\<47\> timer\<46\> timer\<45\> timer\<44\> \
        timer\<43\> timer\<42\> timer\<41\> timer\<40\> timer\<39\> \
        timer\<38\> timer\<37\> timer\<36\> timer\<35\> timer\<34\> \
        timer\<33\> timer\<32\> timer\<31\> timer\<30\> timer\<29\> \
        timer\<28\> timer\<27\> timer\<26\> timer\<25\> timer\<24\> \
        timer\<23\> timer\<22\> timer\<21\> timer\<20\> timer\<19\> \
        timer\<18\> timer\<17\> timer\<16\> timer\<15\> timer\<14\> \
        timer\<13\> timer\<12\> timer\<11\> timer\<10\> timer\<9\> \
        timer\<8\> timer\<7\> timer\<6\> timer\<5\> timer\<4\> timer\<3\> \
        timer\<2\> timer\<1\> timer\<0\> N65 N64 N63 N62 N61 N60 N59 N58 \
        N57 N56 N55 N54 N53 N52 N51 N50 N49 N48 N47 N46 N45 N44 N43 N42 \
        N41 N40 N39 N38 N37 N36 N35 N34 N33 N32 N31 N30 N29 N28 N27 N26 \
        N25 N24 N23 N22 N21 N20 N19 N18 N17 N16 N15 N14 N13 N12 N11 N10 N9 \
        N8 N7 N6 N5 N4 N3 SYNOPSYS_UNCONNECTED__0 inh_gnd inh_gnds inh_vdd \
        inh_vdds) timer_DW01_inc_0_schematic
    U23 (n66 n159 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U131 (N36 nreset n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends timer_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: sleep_controller_DW01_dec_0
// View name: schematic
subckt sleep_controller_DW01_dec_0_schematic A\<31\> A\<30\> A\<29\> \
        A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> \
        A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> \
        A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> \
        A\<3\> A\<2\> A\<1\> A\<0\> SUM\<31\> SUM\<30\> SUM\<29\> \
        SUM\<28\> SUM\<27\> SUM\<26\> SUM\<25\> SUM\<24\> SUM\<23\> \
        SUM\<22\> SUM\<21\> SUM\<20\> SUM\<19\> SUM\<18\> SUM\<17\> \
        SUM\<16\> SUM\<15\> SUM\<14\> SUM\<13\> SUM\<12\> SUM\<11\> \
        SUM\<10\> SUM\<9\> SUM\<8\> SUM\<7\> SUM\<6\> SUM\<5\> SUM\<4\> \
        SUM\<3\> SUM\<2\> SUM\<1\> SUM\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U16 (n49 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (A\<9\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (A\<7\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (A\<3\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (A\<5\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (A\<11\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (A\<13\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (A\<15\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (A\<17\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (A\<19\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (A\<21\> n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (A\<23\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (A\<25\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (A\<27\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (A\<30\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (A\<0\> SUM\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (n34 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n38 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n46 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n42 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (A\<1\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n102 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n97 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n92 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n87 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n82 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n75 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n70 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n65 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n60 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n51 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U95 (A\<0\> n18 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (n80 n79 SUM\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U94 (A\<1\> SUM\<0\> n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U51 (n48 A\<31\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U135 (A\<1\> A\<2\> n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (A\<10\> A\<9\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U138 (A\<8\> A\<7\> n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (A\<6\> A\<5\> n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U136 (A\<4\> A\<3\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U123 (A\<12\> A\<11\> n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U116 (A\<14\> A\<13\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U109 (A\<15\> A\<16\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U102 (A\<18\> A\<17\> n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (A\<20\> A\<19\> n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (A\<21\> A\<22\> n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (A\<24\> A\<23\> n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (A\<26\> A\<25\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (A\<28\> A\<27\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U60 (n55 A\<29\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U55 (n52 n46 SUM\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n53 A\<2\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (SUM\<0\> n18 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n16 n47 SUM\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (A\<31\> n48 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (SUM\<0\> n108 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n6 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n105 n10 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n22 n6 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n106 n7 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n21 n10 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n107 n11 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n19 n11 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n20 n7 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (A\<10\> n32 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n103 n102 SUM\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n33 n32 SUM\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n34 A\<9\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n35 n34 SUM\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (A\<8\> n36 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n37 n36 SUM\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (A\<7\> n38 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (n39 n38 SUM\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (A\<6\> n40 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n41 n40 SUM\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (A\<5\> n42 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n43 n42 SUM\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (A\<4\> n44 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n45 n44 SUM\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (A\<3\> n46 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (A\<11\> n102 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n101 n99 SUM\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n23 n12 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (A\<12\> n99 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n98 n97 SUM\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n100 n12 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (A\<13\> n97 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n96 n94 SUM\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n24 n9 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (A\<14\> n94 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n93 n92 SUM\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n9 n95 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (A\<15\> n92 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n91 n89 SUM\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n25 n5 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (A\<16\> n89 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n88 n87 SUM\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n90 n5 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (A\<17\> n87 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n86 n84 SUM\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n26 n2 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (A\<18\> n84 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n83 n82 SUM\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n2 n85 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (A\<19\> n82 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n81 n77 SUM\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (n14 n4 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (A\<20\> n77 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n76 n75 SUM\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n4 n78 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (A\<21\> n75 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n74 n72 SUM\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n27 n13 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (A\<22\> n72 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n71 n70 SUM\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n13 n73 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (A\<23\> n70 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n69 n67 SUM\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n28 n3 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (A\<24\> n67 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n66 n65 SUM\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n68 n3 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (A\<25\> n65 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n64 n62 SUM\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n29 n8 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (A\<26\> n62 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n61 n60 SUM\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n63 n8 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (A\<27\> n60 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n59 n57 SUM\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n30 n1 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (A\<28\> n57 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n56 n55 SUM\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n58 n1 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (A\<29\> n55 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n54 n15 SUM\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n15 A\<30\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n50 n48 SUM\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n31 n51 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends sleep_controller_DW01_dec_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: sleep_controller
// View name: schematic
subckt sleep_controller_schematic clk nreset data\<31\> data\<30\> \
        data\<29\> data\<28\> data\<27\> data\<26\> data\<25\> data\<24\> \
        data\<23\> data\<22\> data\<21\> data\<20\> data\<19\> data\<18\> \
        data\<17\> data\<16\> data\<15\> data\<14\> data\<13\> data\<12\> \
        data\<11\> data\<10\> data\<9\> data\<8\> data\<7\> data\<6\> \
        data\<5\> data\<4\> data\<3\> data\<2\> data\<1\> data\<0\> \
        sleep_type we spi_finished spi_busy sleep inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U211 (n365 n184 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n362 n241 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U274 (spi_busy we n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n238 nreset n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n239 n240 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U230 (nreset n201 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n202 n203 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (n176 n177 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (n359 n41 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n174 n175 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (n292 n359 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n171 n172 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n169 n170 n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (n223 n224 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n236 n235 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (n233 n234 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U257 (n229 n230 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n227 n228 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n209 n210 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (n221 n222 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n219 n220 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (n215 n216 n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n213 n214 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n52 n321 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n328 n46 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (cnt_minus_one\<1\> n5 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n45 data\<1\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n48 n49 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n279 n320 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n113 n344 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (cnt_minus_one\<17\> n5 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n277 data\<17\> n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n115 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n290 n319 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n342 n105 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (cnt_minus_one\<15\> n5 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n283 data\<15\> n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n107 n108 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n363 n197 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n366 n367 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n197 n367 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (sleep_type n172 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n197 n199 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n40 n43 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n292 n43 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (n322 n303 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n327 n192 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (cnt_minus_one\<0\> n5 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (n325 data\<0\> n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n194 n195 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n305 n317 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n338 n89 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n325 data\<11\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (cnt_minus_one\<11\> n5 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n91 n92 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n305 n316 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n336 n81 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (cnt_minus_one\<9\> n5 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n306 data\<9\> n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n83 n84 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n290 n315 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n354 n153 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n306 data\<27\> n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (cnt_minus_one\<27\> n5 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n155 n156 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n323 n314 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n352 n145 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (cnt_minus_one\<25\> n5 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n293 data\<25\> n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n147 n148 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n322 n313 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n350 n137 n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n293 data\<23\> n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (cnt_minus_one\<23\> n5 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n139 n140 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n52 n312 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n318 n52 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n340 n97 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n348 n129 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (cnt_minus_one\<21\> n5 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n283 data\<21\> n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n131 n132 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (cnt_minus_one\<13\> n5 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n277 data\<13\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n99 n100 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n305 n311 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n334 n73 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (cnt_minus_one\<7\> n5 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (data\<7\> n45 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n45 data\<3\> n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n75 n76 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n304 n310 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n332 n65 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (cnt_minus_one\<5\> n5 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n51 data\<5\> n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n67 n68 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n305 n309 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n57 n330 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (cnt_minus_one\<3\> n5 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n59 n60 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (n290 n308 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n357 n165 n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (data\<30\> n325 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (cnt_minus_one\<30\> n5 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n167 n168 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n290 n300 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n351 n141 n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n293 data\<24\> n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (cnt_minus_one\<24\> n5 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n143 n144 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n322 n307 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n356 n161 n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (n306 data\<29\> n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (cnt_minus_one\<29\> n5 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n163 n164 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (n305 n294 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n358 n188 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n325 data\<31\> n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (cnt_minus_one\<31\> n5 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (n190 n191 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n325 data\<16\> n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (cnt_minus_one\<16\> n5 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n111 n112 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n304 n286 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n343 n109 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n279 n302 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n355 n157 n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n306 data\<28\> n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n159 n160 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (cnt_minus_one\<28\> n5 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n306 data\<18\> n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (cnt_minus_one\<18\> n5 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n119 n120 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n304 n287 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n345 n117 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n322 n301 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n322 n289 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n353 n149 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (cnt_minus_one\<26\> n5 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (data\<26\> n51 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n51 data\<4\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n151 n152 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n121 n346 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (cnt_minus_one\<19\> n5 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (n283 data\<19\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n283 data\<8\> n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n123 n124 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (cnt_minus_one\<8\> n5 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n79 n80 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n304 n299 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n335 n77 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n304 n295 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n339 n93 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (cnt_minus_one\<12\> n5 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n293 data\<12\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n293 data\<22\> n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n95 n96 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (cnt_minus_one\<22\> n5 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n135 n136 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n279 n288 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n349 n133 n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (cnt_minus_one\<4\> n5 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n63 n64 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n323 n297 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n331 n61 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n298 n279 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (n333 n69 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (cnt_minus_one\<6\> n5 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (data\<6\> n277 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n71 n72 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n296 n279 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n329 n53 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n277 data\<2\> n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (cnt_minus_one\<2\> n5 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n55 n56 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n277 data\<20\> n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (cnt_minus_one\<20\> n5 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n127 n128 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n323 n282 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n347 n125 n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n323 n285 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n103 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (cnt_minus_one\<14\> n5 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n341 n101 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n323 n284 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n85 n337 n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (cnt_minus_one\<10\> n5 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n45 data\<10\> n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n87 n88 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n45 data\<14\> n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (spi_finished n365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U329 (n185 n360 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U332 (spi_busy n364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U330 (n242 n362 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n38 n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n10 n291 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U334 (n206 n366 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U290 (n8 n321 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U297 (n47 n328 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n326 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U289 (n28 n320 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U313 (n114 n344 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n324 n279 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n326 n277 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U288 (n18 n319 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U311 (n106 n342 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (n324 n290 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n326 n283 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U295 (n51 n326 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U328 (n178 n359 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n50 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n4 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n280 n281 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n200 n280 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n41 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n173 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n2 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U287 (n20 n318 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (nreset n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U335 (n205 n367 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n40 n292 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n41 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n291 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (nreset n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n172 n278 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U331 (sleep_type n363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U294 (n326 n325 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U293 (n52 n324 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U292 (n324 n323 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U291 (n324 n322 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U296 (n193 n327 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n11 n303 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U286 (n22 n317 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U307 (n90 n338 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U285 (n12 n316 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U305 (n82 n336 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U284 (n30 n315 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U323 (n154 n354 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U283 (n32 n314 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U321 (n146 n352 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U282 (n34 n313 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U319 (n138 n350 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U281 (n24 n312 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U317 (n130 n348 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U309 (n98 n340 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U280 (n14 n311 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U303 (n74 n334 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U279 (n16 n310 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U301 (n66 n332 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U278 (n6 n309 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U299 (n58 n330 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U277 (n36 n308 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U326 (n166 n357 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U320 (n142 n351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n33 n300 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n37 n307 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U325 (n162 n356 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U327 (n189 n358 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (n9 n294 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U312 (n110 n343 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (n29 n286 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n39 n302 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U324 (n158 n355 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n326 n306 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n326 n293 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (n324 n305 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n324 n304 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U314 (n118 n345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n27 n287 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (n31 n301 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U322 (n150 n353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U315 (n122 n346 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n26 n289 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U304 (n78 n335 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n13 n299 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U308 (n94 n339 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n21 n295 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U318 (n134 n349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n35 n288 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U300 (n62 n331 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n17 n297 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (n15 n298 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U302 (n70 n333 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U298 (n54 n329 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n7 n296 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U316 (n126 n347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n25 n282 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (n19 n285 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U310 (n102 n341 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n23 n284 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U306 (n86 n337 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    sleep_reg (clk n361 sleep NeTt_917 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_1_ (clk n274 NeTt_918 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_0_ (clk n273 NeTt_919 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_1_ (clk n243 NeTt_920 n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_17_ (clk n259 NeTt_921 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_15_ (clk n257 NeTt_922 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_13_ (clk n255 NeTt_923 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_0_ (clk n276 NeTt_924 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_11_ (clk n253 NeTt_925 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_9_ (clk n251 NeTt_926 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_27_ (clk n269 NeTt_927 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_25_ (clk n267 NeTt_928 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_23_ (clk n265 NeTt_929 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_21_ (clk n263 NeTt_930 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_7_ (clk n249 NeTt_931 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_5_ (clk n247 NeTt_932 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_3_ (clk n245 NeTt_933 n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_30_ (clk n272 NeTt_934 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_24_ (clk n266 NeTt_935 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_29_ (clk n271 NeTt_936 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_31_ (clk n275 NeTt_937 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_16_ (clk n258 NeTt_938 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_28_ (clk n270 NeTt_939 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_18_ (clk n260 NeTt_940 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_26_ (clk n268 NeTt_941 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_19_ (clk n261 NeTt_942 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_8_ (clk n250 NeTt_943 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_12_ (clk n254 NeTt_944 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_22_ (clk n264 NeTt_945 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_4_ (clk n246 NeTt_946 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_6_ (clk n248 NeTt_947 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_2_ (clk n244 NeTt_948 n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_20_ (clk n262 NeTt_949 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_14_ (clk n256 NeTt_950 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    cnt_reg_10_ (clk n252 NeTt_951 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    U210 (n183 n364 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U212 (n187 n186 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U208 (n181 n44 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U209 (n182 n360 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U275 (n363 n281 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U267 (we n281 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U270 (n184 n367 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U234 (n187 n204 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U235 (n205 n366 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U232 (n186 n184 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U203 (n363 n364 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U202 (n173 n278 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U198 (sleep_type n3 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U236 (n207 n208 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U260 (n231 n232 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U253 (n225 n226 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U266 (n289 n321 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U265 (n320 n287 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U263 (n313 n288 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n312 n282 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U259 (n317 n295 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U258 (n303 n284 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U256 (n319 n286 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U255 (n318 n285 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U245 (n217 n218 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U238 (n211 n212 n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U251 (n310 n297 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U250 (n294 n309 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U248 (n316 n299 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U247 (n311 n298 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U244 (n315 n301 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U243 (n300 n314 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U241 (n296 n308 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U240 (n307 n302 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U224 (n198 n278 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U205 (n179 n3 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U206 (n180 n1 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U221 (n196 n1 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U233 (n40 n42 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U229 (n200 n44 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U271 (n43 n291 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    sub_30 (n294 n308 n307 n302 n315 n301 n314 n300 n313 n288 n312 n282 \
        n289 n287 n320 n286 n319 n285 n318 n295 n317 n284 n316 n299 n311 \
        n298 n310 n297 n309 n296 n321 n303 cnt_minus_one\<31\> \
        cnt_minus_one\<30\> cnt_minus_one\<29\> cnt_minus_one\<28\> \
        cnt_minus_one\<27\> cnt_minus_one\<26\> cnt_minus_one\<25\> \
        cnt_minus_one\<24\> cnt_minus_one\<23\> cnt_minus_one\<22\> \
        cnt_minus_one\<21\> cnt_minus_one\<20\> cnt_minus_one\<19\> \
        cnt_minus_one\<18\> cnt_minus_one\<17\> cnt_minus_one\<16\> \
        cnt_minus_one\<15\> cnt_minus_one\<14\> cnt_minus_one\<13\> \
        cnt_minus_one\<12\> cnt_minus_one\<11\> cnt_minus_one\<10\> \
        cnt_minus_one\<9\> cnt_minus_one\<8\> cnt_minus_one\<7\> \
        cnt_minus_one\<6\> cnt_minus_one\<5\> cnt_minus_one\<4\> \
        cnt_minus_one\<3\> cnt_minus_one\<2\> cnt_minus_one\<1\> \
        cnt_minus_one\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        sleep_controller_DW01_dec_0_schematic
    U43 (n237 n361 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
ends sleep_controller_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: SPI_top3
// View name: schematic
subckt soc_no_opt_16may_SPI_top3_schematic clk nreset start byte_complete \
        data_in\<7\> data_in\<6\> data_in\<5\> data_in\<4\> data_in\<3\> \
        data_in\<2\> data_in\<1\> data_in\<0\> data_out\<7\> data_out\<6\> \
        data_out\<5\> data_out\<4\> data_out\<3\> data_out\<2\> \
        data_out\<1\> data_out\<0\> mosi miso sclk inh_gnd inh_gnds \
        inh_vdd inh_vdds
    U112 (n160 n77 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (data_out\<7\> n123 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n101 n102 N53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n22 n155 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n96 n125 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n97 n98 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n129 n72 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (n68 n64 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n70 n69 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n127 n136 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n66 n67 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (n161 n77 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n76 n64 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (n65 n18 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n74 n75 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n64 n120 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n127 n155 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n62 n63 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n164 n137 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n86 n156 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n84 n85 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n156 n61 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n162 n59 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (n125 n95 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n139 n135 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n93 n94 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (data_out\<6\> n5 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n171 n30 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (data_in\<6\> n7 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (data_out\<5\> n134 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n32 n33 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n4 data_out\<5\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n170 n34 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (data_in\<5\> n7 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n134 data_out\<4\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n36 n37 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n4 data_out\<4\> n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n169 n38 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (data_in\<4\> n7 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (data_out\<3\> n134 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n40 n41 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n4 data_out\<3\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n168 n42 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n120 n20 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n82 n81 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (start n83 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n125 n89 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n21 n103 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n15 n79 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n92 n89 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n125 n17 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n22 n20 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n18 n136 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n173 n83 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n4 data_out\<0\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n4 data_out\<1\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n165 n54 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (miso n134 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (data_in\<0\> n7 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n56 n57 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n166 n50 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (data_in\<1\> n7 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (data_out\<0\> n134 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n52 n53 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (data_out\<2\> n5 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n167 n46 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (data_in\<2\> n7 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n134 data_out\<1\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n48 n49 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (data_out\<7\> n5 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U21 (n172 n23 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (data_in\<7\> n7 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (data_out\<6\> n134 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n25 n26 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (data_in\<3\> n7 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (data_out\<2\> n134 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n44 n45 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n14 n160 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n10 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U129 (n11 n130 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U150 (n78 n161 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U144 (n9 n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U135 (n138 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U151 (n60 n162 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U146 (n8 n156 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n12 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U143 (n153 data_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U160 (n31 n171 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n3 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U142 (n151 data_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U159 (n35 n170 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U141 (n149 data_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U158 (n39 n169 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U140 (n147 data_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U157 (n43 n168 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U147 (n157 sclk inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U127 (n71 n128 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U163 (start n174 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n28 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n6 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U121 (nreset n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U123 (nreset n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U153 (n90 n164 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U152 (n87 n163 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U148 (n13 mosi inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n160 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n58 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U125 (n65 n126 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U126 (n126 n127 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U145 (n121 n155 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n154 n121 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n29 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U122 (n77 n123 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n20 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U124 (n122 n125 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n154 n120 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U162 (n73 n173 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U128 (n128 n129 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n21 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n130 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U134 (n22 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U133 (n89 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n16 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U136 (n15 n139 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n3 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U154 (n55 n165 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U137 (n141 data_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U155 (n51 n166 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U138 (n143 data_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U139 (n145 data_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U156 (n47 n167 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U130 (n132 data_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U161 (n24 n172 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U131 (n27 n133 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U132 (n133 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U103 (byte_complete n123 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U108 (n100 n19 byte_complete inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U104 (n120 n81 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U74 (n73 n2 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U79 (n72 n128 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U89 (n137 n163 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (n163 n156 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n139 n135 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U115 (n104 n122 N48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U116 (n58 n129 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U117 (n22 n105 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (n80 n122 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U63 (n173 n174 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U94 (n156 n124 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (n61 n91 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U90 (n88 n17 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n120 n130 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U62 (n7 n2 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U81 (n156 n137 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U119 (n120 n99 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n99 n154 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U82 (n127 n122 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U59 (n7 n5 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    output_reg_reg (clk N53 NeTt_436 n14 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    state_reg_1_ (clk n116 NeTt_437 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_2_ (clk n117 NeTt_438 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_0_ (clk n115 NeTt_439 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    counter_reg_2_ (clk n118 NeTt_440 n138 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    counter_reg_1_ (clk n114 NeTt_441 n8 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    counter_reg_0_ (clk n119 NeTt_442 n12 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    regs_reg_6_ (clk n107 NeTt_443 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_5_ (clk n108 NeTt_444 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_4_ (clk n109 NeTt_445 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_3_ (clk n110 NeTt_446 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    sclk_i_reg (clk N48 NeTt_447 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_0_ (clk n113 NeTt_448 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_1_ (clk n112 NeTt_449 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_2_ (clk n111 NeTt_450 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    regs_reg_7_ (clk n106 NeTt_451 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
ends soc_no_opt_16may_SPI_top3_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: SPI_controller
// View name: schematic
subckt soc_no_opt_16may_SPI_controller_schematic clk nreset request \
        data_in\<31\> data_in\<30\> data_in\<29\> data_in\<28\> \
        data_in\<27\> data_in\<26\> data_in\<25\> data_in\<24\> \
        data_in\<23\> data_in\<22\> data_in\<21\> data_in\<20\> \
        data_in\<19\> data_in\<18\> data_in\<17\> data_in\<16\> \
        data_in\<15\> data_in\<14\> data_in\<13\> data_in\<12\> \
        data_in\<11\> data_in\<10\> data_in\<9\> data_in\<8\> data_in\<7\> \
        data_in\<6\> data_in\<5\> data_in\<4\> data_in\<3\> data_in\<2\> \
        data_in\<1\> data_in\<0\> data_out\<31\> data_out\<30\> \
        data_out\<29\> data_out\<28\> data_out\<27\> data_out\<26\> \
        data_out\<25\> data_out\<24\> data_out\<23\> data_out\<22\> \
        data_out\<21\> data_out\<20\> data_out\<19\> data_out\<18\> \
        data_out\<17\> data_out\<16\> data_out\<15\> data_out\<14\> \
        data_out\<13\> data_out\<12\> data_out\<11\> data_out\<10\> \
        data_out\<9\> data_out\<8\> data_out\<7\> data_out\<6\> \
        data_out\<5\> data_out\<4\> data_out\<3\> data_out\<2\> \
        data_out\<1\> data_out\<0\> busy finished clear start miso mosi \
        sclk cs1 cs2 cs3 cs4 inh_gnd inh_gnds inh_vdd inh_vdds
    U258 (n393 n220 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n223 n224 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U255 (n225 n226 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (finished n206 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U232 (n202 n203 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U241 (n210 n211 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (n212 n213 n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (n237 n298 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n339 n234 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U266 (n235 n236 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n230 n298 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n50 n343 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U265 (n343 n234 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (n228 n229 n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n343 n215 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n205 n2 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (n204 n392 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n322 n391 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n6 data_in\<0\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n61 n62 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n290 n391 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n6 data_in\<1\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n59 n60 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n72 data_in\<17\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (data_out\<9\> n51 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n123 n124 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (data_out\<17\> n4 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n375 n121 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (n238 n211 n398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n398 n289 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U271 (n396 n288 n402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n240 n289 n401 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (n200 start n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n199 n2 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n198 nreset n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n65 request n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n64 nreset n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U250 (byte_complete n220 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U283 (n341 n319 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U280 (n341 n49 n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n340 n49 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (n398 n242 n399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (n241 n288 n400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n284 data_out\<0\> n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n358 n189 n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (data_in\<0\> n336 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n51 slave_data\<0\> n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (n191 n192 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (data_out\<24\> n316 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n382 n93 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (data_in\<24\> n344 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (data_out\<16\> n71 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n95 n96 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (data_out\<25\> n316 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n383 n89 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (data_out\<17\> n71 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n345 data_in\<25\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n91 n92 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (data_out\<1\> n316 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n359 n185 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (data_in\<1\> n1 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n351 slave_data\<1\> n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (n187 n188 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (data_out\<26\> n355 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (data_out\<9\> n355 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n384 n85 n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n345 data_in\<26\> n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (data_out\<18\> n351 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n87 n88 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (data_out\<27\> n316 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n385 n81 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (data_out\<7\> n316 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (n365 n161 n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (slave_data\<7\> n335 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (data_in\<7\> n349 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (data_in\<10\> n349 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n163 n164 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (data_in\<27\> n1 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (data_out\<19\> n351 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n83 n84 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (data_in\<29\> n1 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (data_out\<21\> n51 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n75 n76 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (data_out\<29\> n4 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (data_out\<28\> n4 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n387 n73 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n386 n77 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (data_out\<20\> n71 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (data_in\<28\> n346 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (n346 data_in\<9\> n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n79 n80 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (n71 data_out\<23\> n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n345 data_in\<31\> n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n195 n196 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (data_out\<31\> n287 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (n287 data_out\<3\> n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (n389 n193 n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n367 n153 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n352 data_out\<1\> n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n155 n156 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (data_out\<10\> n67 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n368 n149 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (data_out\<2\> n51 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n151 n152 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n51 slave_data\<3\> n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (data_in\<3\> n344 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U202 (n179 n180 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n361 n177 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (data_out\<11\> n67 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n369 n145 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (data_in\<11\> n344 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (data_out\<3\> n351 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n147 n148 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (data_out\<12\> n67 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n370 n141 n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (data_out\<22\> n67 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (data_in\<2\> n344 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (n353 slave_data\<2\> n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n183 n184 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U206 (data_out\<2\> n355 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U205 (n360 n181 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n380 n101 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (data_in\<22\> n349 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n351 data_out\<14\> n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (data_out\<4\> n351 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n143 n144 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (data_in\<12\> n346 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n103 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (data_out\<30\> n287 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n388 n66 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n345 data_in\<30\> n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n345 data_in\<20\> n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (data_out\<22\> n335 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n69 n70 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (data_out\<12\> n353 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n111 n112 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (data_out\<20\> n355 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n378 n109 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (data_out\<16\> n4 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (data_out\<6\> n4 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n374 n125 n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n364 n165 n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (slave_data\<6\> n353 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (data_in\<6\> n346 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n167 n168 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (data_in\<16\> n349 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n352 data_out\<8\> n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n127 n128 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (data_out\<8\> n284 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n366 n157 n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (data_out\<0\> n353 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (data_in\<8\> n336 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n159 n160 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n355 data_out\<18\> n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n376 n117 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (data_out\<13\> n355 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n371 n137 n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (data_in\<13\> n349 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (n352 data_out\<5\> n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n139 n140 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (data_in\<18\> n349 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n335 data_out\<10\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n119 n120 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (data_out\<19\> n287 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n377 n113 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (data_in\<19\> n344 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n352 data_out\<11\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n115 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (data_in\<4\> n344 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (slave_data\<4\> n353 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n175 n176 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (data_out\<4\> n287 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (n362 n173 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (slave_data\<5\> n353 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (data_in\<5\> n336 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n171 n172 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (data_out\<5\> n287 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n363 n169 n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n352 data_out\<15\> n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n336 data_in\<23\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n99 n100 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (data_in\<21\> n336 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (data_out\<13\> n335 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n107 n108 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (data_out\<21\> n284 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n379 n105 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (data_out\<23\> n284 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n381 n97 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (data_out\<14\> n287 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n372 n133 n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (data_in\<14\> n346 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n335 data_out\<6\> n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n135 n136 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (data_in\<15\> n346 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (data_out\<7\> n335 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n131 n132 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (data_out\<15\> n284 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n373 n129 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (data_in\<3\> n6 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n288 n391 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n55 n56 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (data_in\<4\> n6 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n52 n53 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n289 n391 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (data_in\<2\> n6 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n57 n58 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n320 n391 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    state_reg_1_ (clk n281 NeTt_1024 n14 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    msg_cnt_reg_0_ (clk n283 NeTt_1025 n9 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    msg_cnt_reg_1_ (clk n282 NeTt_1026 n19 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    state_reg_0_ (clk n280 state\[0\] NeTt_1027 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    settings_reg_0_ (clk n247 NeTt_1028 n13 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    settings_reg_1_ (clk n246 n8 NeTt_1029 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_17_ (clk n261 NeTt_1030 n38 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_0_ (clk n278 NeTt_1031 n46 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_24_ (clk n254 NeTt_1032 n43 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_25_ (clk n253 NeTt_1033 n47 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_1_ (clk n277 NeTt_1034 n40 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_26_ (clk n252 NeTt_1035 n41 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_27_ (clk n251 NeTt_1036 n34 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_7_ (clk n271 NeTt_1037 n17 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_29_ (clk n249 NeTt_1038 n30 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_28_ (clk n250 NeTt_1039 n26 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_31_ (clk n279 NeTt_1040 n18 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_9_ (clk n269 NeTt_1041 n39 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_10_ (clk n268 NeTt_1042 n32 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_3_ (clk n275 NeTt_1043 n37 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_11_ (clk n267 NeTt_1044 n36 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_12_ (clk n266 NeTt_1045 n28 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_2_ (clk n276 NeTt_1046 n33 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_22_ (clk n256 NeTt_1047 n23 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_30_ (clk n248 NeTt_1048 n22 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_20_ (clk n258 NeTt_1049 n27 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_16_ (clk n262 NeTt_1050 n44 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_6_ (clk n272 NeTt_1051 n25 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_8_ (clk n270 NeTt_1052 n45 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_18_ (clk n260 NeTt_1053 n42 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_13_ (clk n265 NeTt_1054 n20 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_19_ (clk n259 NeTt_1055 n35 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_4_ (clk n274 NeTt_1056 n29 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_5_ (clk n273 NeTt_1057 n21 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_21_ (clk n257 NeTt_1058 n31 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_23_ (clk n255 NeTt_1059 n15 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_14_ (clk n264 NeTt_1060 n24 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    message_reg_15_ (clk n263 NeTt_1061 n16 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    settings_reg_2_ (clk n245 NeTt_1062 n12 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    settings_reg_3_ (clk n244 NeTt_1063 n11 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    settings_reg_4_ (clk n243 NeTt_1064 n10 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U360 (byte_complete n393 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U286 (n14 n319 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n9 n299 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U362 (n233 n395 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U310 (n19 n343 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U364 (n216 n397 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U307 (state\[0\] n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U357 (n201 n390 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U359 (n65 n392 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U288 (n13 n321 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n8 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U342 (n122 n375 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n354 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n38 data_out\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U363 (n239 n396 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U315 (n347 cs4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U314 (n402 n347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U305 (n337 cs3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U304 (n401 n337 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U323 (n67 n356 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U358 (n63 n391 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n54 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n356 n316 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U321 (n71 n354 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n211 n298 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n299 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n321 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U306 (n50 n339 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U324 (nreset n357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (nreset n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U289 (n48 n322 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (n7 n290 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n227 finished inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U308 (n340 n341 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U309 (n340 n342 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n319 n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n394 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U361 (n197 n394 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n356 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U322 (n356 n355 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U320 (n354 n353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U319 (n354 n352 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U318 (n354 n351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U317 (n72 n350 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U302 (n354 n335 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U316 (n350 n349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U313 (n350 n346 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U312 (n350 n345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U311 (n350 n344 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n399 n296 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (n296 cs1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n398 n285 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U284 (n400 n317 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U285 (n317 cs2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U301 (n46 data_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U325 (n190 n358 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U303 (n350 n336 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n350 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U300 (n43 data_out\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U349 (n94 n382 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U299 (n47 data_out\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U350 (n90 n383 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U298 (n40 data_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U326 (n186 n359 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U297 (n41 data_out\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U351 (n86 n384 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U296 (n34 data_out\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U352 (n82 n385 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U332 (n162 n365 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n17 data_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U354 (n74 n387 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n30 data_out\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U295 (n26 data_out\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U353 (n78 n386 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U356 (n194 n389 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n18 data_out\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U294 (n39 data_out\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U334 (n154 n367 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U293 (n32 data_out\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U335 (n150 n368 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U328 (n178 n361 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n37 data_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U292 (n36 data_out\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U336 (n146 n369 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U291 (n28 data_out\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U337 (n142 n370 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n285 busy inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U327 (n182 n360 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n33 data_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U290 (n23 data_out\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U347 (n102 n380 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n22 data_out\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U355 (n68 n388 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U345 (n110 n378 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n27 data_out\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U43 (n44 data_out\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U341 (n126 n374 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U331 (n166 n364 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (n25 data_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U42 (n45 data_out\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U333 (n158 n366 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n42 data_out\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U343 (n118 n376 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U338 (n138 n371 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n20 data_out\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U38 (n35 data_out\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U344 (n114 n377 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U329 (n174 n362 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (n29 data_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U330 (n170 n363 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (n21 data_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U348 (n98 n381 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U346 (n106 n379 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n31 data_out\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n15 data_out\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (n24 data_out\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U339 (n134 n372 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U340 (n130 n373 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n16 data_out\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n356 n287 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n356 n284 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U287 (n12 n320 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n11 n288 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n10 n289 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U257 (clear n227 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U256 (start n320 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U238 (clear n320 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U249 (n219 n2 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U239 (n207 n357 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U240 (n208 n209 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U253 (n48 n299 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U252 (n50 n321 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U251 (n221 n222 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U268 (n339 n357 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U261 (n231 n3 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U263 (n50 n343 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n232 n395 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U244 (n215 n343 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U243 (n214 n397 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U231 (n390 n357 n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U274 (n288 n285 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U246 (n218 n217 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U247 (n322 n7 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U248 (n48 n290 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U230 (n319 n342 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U61 (n391 n3 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U226 (n316 n394 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U224 (n197 n4 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U270 (n238 n3 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U281 (n220 finished n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U282 (n49 n342 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U235 (n205 start n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U278 (n289 n288 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U276 (n289 n285 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    SPI_top (clk nreset n298 byte_complete data_out\<31\> data_out\<30\> \
        data_out\<29\> data_out\<28\> data_out\<27\> data_out\<26\> \
        data_out\<25\> data_out\<24\> slave_data\<7\> slave_data\<6\> \
        slave_data\<5\> slave_data\<4\> slave_data\<3\> slave_data\<2\> \
        slave_data\<1\> slave_data\<0\> mosi miso sclk inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_SPI_top3_schematic
ends soc_no_opt_16may_SPI_controller_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: spi_startup_DW01_inc_0
// View name: schematic
subckt soc_no_opt_16may_spi_startup_DW01_inc_0_schematic A\<10\> A\<9\> \
        A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> A\<3\> A\<2\> A\<1\> A\<0\> \
        SUM\<10\> SUM\<9\> SUM\<8\> SUM\<7\> SUM\<6\> SUM\<5\> SUM\<4\> \
        SUM\<3\> SUM\<2\> SUM\<1\> SUM\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U47 (n13 A\<0\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n41 n42 SUM\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (A\<1\> SUM\<0\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n39 A\<2\> n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n6 n38 SUM\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (n37 A\<3\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n35 n36 SUM\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n14 n5 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n48 A\<4\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n33 A\<4\> n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n11 n32 SUM\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n31 A\<5\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n29 n30 SUM\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n4 n15 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n27 A\<6\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n10 n26 SUM\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n25 A\<7\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (n24 n23 SUM\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (n2 n3 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U21 (n21 A\<8\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (n9 n20 SUM\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (A\<9\> n19 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (n17 n18 SUM\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (n16 n8 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n7 n43 SUM\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (A\<10\> n44 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n49 A\<2\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n47 A\<6\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (A\<8\> n46 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (A\<1\> A\<0\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n5 A\<3\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (A\<5\> n4 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (A\<7\> n2 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n8 A\<9\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U6 (n40 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n5 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n34 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n28 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n22 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (A\<9\> n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n45 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (A\<1\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (A\<0\> SUM\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n37 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (A\<3\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (A\<5\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n31 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (A\<7\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n25 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n19 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (A\<2\> n39 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U57 (n14 n1 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U36 (A\<4\> n33 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U29 (n27 A\<6\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U22 (A\<8\> n21 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U50 (n44 A\<10\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U59 (SUM\<0\> n13 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U55 (n31 n15 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U53 (n25 n3 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_spi_startup_DW01_inc_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: spi_startup
// View name: schematic
subckt soc_no_opt_16may_spi_startup_schematic clk nreset skip_startup \
        data_to_spi\<31\> data_to_spi\<30\> data_to_spi\<29\> \
        data_to_spi\<28\> data_to_spi\<27\> data_to_spi\<26\> \
        data_to_spi\<25\> data_to_spi\<24\> data_to_spi\<23\> \
        data_to_spi\<22\> data_to_spi\<21\> data_to_spi\<20\> \
        data_to_spi\<19\> data_to_spi\<18\> data_to_spi\<17\> \
        data_to_spi\<16\> data_to_spi\<15\> data_to_spi\<14\> \
        data_to_spi\<13\> data_to_spi\<12\> data_to_spi\<11\> \
        data_to_spi\<10\> data_to_spi\<9\> data_to_spi\<8\> \
        data_to_spi\<7\> data_to_spi\<6\> data_to_spi\<5\> \
        data_to_spi\<4\> data_to_spi\<3\> data_to_spi\<2\> \
        data_to_spi\<1\> data_to_spi\<0\> data_from_spi\<31\> \
        data_from_spi\<30\> data_from_spi\<29\> data_from_spi\<28\> \
        data_from_spi\<27\> data_from_spi\<26\> data_from_spi\<25\> \
        data_from_spi\<24\> data_from_spi\<23\> data_from_spi\<22\> \
        data_from_spi\<21\> data_from_spi\<20\> data_from_spi\<19\> \
        data_from_spi\<18\> data_from_spi\<17\> data_from_spi\<16\> \
        data_from_spi\<15\> data_from_spi\<14\> data_from_spi\<13\> \
        data_from_spi\<12\> data_from_spi\<11\> data_from_spi\<10\> \
        data_from_spi\<9\> data_from_spi\<8\> data_from_spi\<7\> \
        data_from_spi\<6\> data_from_spi\<5\> data_from_spi\<4\> \
        data_from_spi\<3\> data_from_spi\<2\> data_from_spi\<1\> \
        data_from_spi\<0\> spi_finished spi_start spi_clear spi_settings \
        data_mem\<31\> data_mem\<30\> data_mem\<29\> data_mem\<28\> \
        data_mem\<27\> data_mem\<26\> data_mem\<25\> data_mem\<24\> \
        data_mem\<23\> data_mem\<22\> data_mem\<21\> data_mem\<20\> \
        data_mem\<19\> data_mem\<18\> data_mem\<17\> data_mem\<16\> \
        data_mem\<15\> data_mem\<14\> data_mem\<13\> data_mem\<12\> \
        data_mem\<11\> data_mem\<10\> data_mem\<9\> data_mem\<8\> \
        data_mem\<7\> data_mem\<6\> data_mem\<5\> data_mem\<4\> \
        data_mem\<3\> data_mem\<2\> data_mem\<1\> data_mem\<0\> \
        address\<8\> address\<7\> address\<6\> address\<5\> address\<4\> \
        address\<3\> address\<2\> address\<1\> address\<0\> data_we \
        instr_we done inh_gnd inh_gnds inh_vdd inh_vdds
    add_52 (n178 n189 address\<8\> address\<7\> address\<6\> address\<5\> \
        address\<4\> address\<3\> address\<2\> address\<1\> address\<0\> \
        word_cnt_incr\<10\> word_cnt_incr\<9\> word_cnt_incr\<8\> \
        word_cnt_incr\<7\> word_cnt_incr\<6\> word_cnt_incr\<5\> \
        word_cnt_incr\<4\> word_cnt_incr\<3\> word_cnt_incr\<2\> \
        word_cnt_incr\<1\> word_cnt_incr\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_spi_startup_DW01_inc_0_schematic
    U121 (n233 n103 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n100 n84 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n99 n98 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n101 n102 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n83 n84 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n82 n221 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n226 n85 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n1 nreset n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n167 n97 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n200 n92 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n113 n213 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n120 n106 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n122 n3 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n111 n112 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n123 n124 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n3 n128 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n103 n131 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n129 n130 N176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n108 n84 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n32 n225 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n107 n106 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n202 n172 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n214 n104 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n3 n70 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n201 n33 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n185 n201 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n202 n224 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n115 n116 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n200 n30 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n29 n30 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (n193 n200 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (n33 n32 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n185 n32 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n194 n76 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n193 n29 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (skip_startup n2 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n131 n87 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n88 n3 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n3 n195 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (n151 n152 N167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n139 n140 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (address\<8\> n189 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n231 address\<7\> n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (address\<5\> address\<6\> n147 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U169 (n144 address\<1\> n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n230 address\<4\> n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (address\<3\> address\<2\> n143 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U188 (n205 n131 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n136 n221 N172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n219 n131 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (address\<0\> n197 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (word_cnt_incr\<0\> n207 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n56 n57 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n189 n197 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (word_cnt_incr\<9\> n207 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n38 n39 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (address\<5\> n197 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (word_cnt_incr\<5\> n207 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n46 n47 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (address\<3\> n197 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (word_cnt_incr\<3\> n207 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n50 n51 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (address\<1\> n197 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (word_cnt_incr\<1\> n207 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n54 n55 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (address\<2\> n197 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (word_cnt_incr\<2\> n207 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n52 n53 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (address\<8\> n197 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (word_cnt_incr\<8\> n207 n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n40 n41 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (address\<4\> n197 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (word_cnt_incr\<4\> n207 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n48 n49 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (address\<6\> n197 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (word_cnt_incr\<6\> n207 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n44 n45 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n178 n197 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (word_cnt_incr\<10\> n207 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n34 n35 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (word_cnt_incr\<7\> n207 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (address\<7\> n197 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n42 n43 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n64 n3 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n62 n63 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n222 n66 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n68 n69 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n73 n3 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (n65 nreset n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n149 n152 N166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n209 n149 N171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n98 n150 N168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n3 n72 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (data_from_spi\<0\> n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U199 (n10 n185 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U239 (n88 n226 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U208 (n8 n193 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (nreset n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n5 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U226 (n121 n210 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U231 (n59 n218 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U221 (n203 n205 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U228 (n105 n214 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (n9 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U224 (n198 done inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n168 n169 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (n134 n168 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U229 (n117 n216 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (n229 n167 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U244 (spi_finished n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U230 (n119 n217 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U236 (n97 n223 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U237 (n110 n224 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U206 (n126 n191 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (n109 n175 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U238 (n71 n225 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n225 n171 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n185 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U220 (n203 n204 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n193 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U216 (n29 n200 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U227 (n92 n213 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n213 n172 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U219 (n86 n203 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n2 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n232 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n31 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (n31 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U217 (n28 n201 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U218 (n28 n202 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n224 n170 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U207 (n191 n192 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n191 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (n175 n176 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (n175 n177 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U210 (n77 n194 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U211 (n194 n195 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U225 (N167 n209 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U222 (n36 n206 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U223 (n206 n207 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U241 (n96 n229 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U243 (n147 n231 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U242 (n143 n230 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U232 (n137 n219 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n234 n179 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U204 (n18 n189 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U203 (n14 address\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U202 (n16 address\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U201 (n7 address\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U198 (n6 address\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U197 (n11 address\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U57 (n15 address\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U56 (n13 address\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U53 (n17 n178 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (n12 address\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U212 (n37 n196 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U213 (n196 n197 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U240 (n61 n228 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U235 (n67 n222 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U233 (n150 n220 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U234 (N168 n221 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (n179 address\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    state_reg_2_ (clk n211 NeTt_790 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_1_ (clk n215 NeTt_791 n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    state_reg_0_ (clk n165 n5 NeTt_792 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    spi_clear_reg (clk N176 spi_clear NeTt_793 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    state_reg_3_ (clk n164 NeTt_794 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    done_reg (clk n227 NeTt_795 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    spi_start_reg (clk N172 spi_start NeTt_796 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_0_ (clk n163 n234 NeTt_797 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_9_ (clk n154 NeTt_798 n18 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_5_ (clk n158 NeTt_799 n14 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_3_ (clk n160 NeTt_800 n16 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_1_ (clk n162 NeTt_801 n7 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_2_ (clk n161 NeTt_802 n6 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_8_ (clk n155 NeTt_803 n11 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_4_ (clk n159 NeTt_804 n15 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_6_ (clk n157 NeTt_805 n13 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_10_ (clk n153 NeTt_806 n17 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    word_cnt_reg_7_ (clk n156 NeTt_807 n12 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_to_spi_reg_26_ (clk n166 data_to_spi\<26\> NeTt_808 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    instr_we_reg (clk N174 instr_we NeTt_809 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_we_reg (clk n212 data_we NeTt_810 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_to_spi_reg_0_ (clk N166 data_to_spi\<0\> NeTt_811 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    spi_settings_reg (clk N171 spi_settings NeTt_812 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_to_spi_reg_1_ (clk n174 data_to_spi\<1\> NeTt_813 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_to_spi_reg_24_ (clk n190 data_to_spi\<24\> NeTt_814 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    data_to_spi_reg_25_ (clk n199 data_to_spi\<25\> NeTt_815 inh_gnd \
