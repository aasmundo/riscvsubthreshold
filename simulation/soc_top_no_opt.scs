        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U200 (n89 n211 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U209 (n78 n215 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U215 (n132 n227 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U214 (n135 n212 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U49 (n209 n174 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U205 (n221 n190 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U33 (n98 n199 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U120 (n195 n204 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U149 (n128 n195 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (n81 n33 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U111 (n90 n91 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U110 (n87 n204 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n30 n81 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (n79 n80 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (n172 n93 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n94 n95 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U143 (n220 n210 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U147 (n167 n218 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U146 (n125 n205 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U133 (n74 n216 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (n118 n70 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U138 (n76 n1 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U132 (n114 n2 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U97 (spi_finished n229 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (n86 n217 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U140 (n103 n87 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U157 (n133 n169 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U160 (n127 n169 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U155 (n223 n167 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U103 (n74 n75 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U128 (n170 n176 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U101 (n70 n171 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U175 (n148 n169 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U189 (n2 n232 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U126 (n172 n2 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U190 (n148 n176 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U152 (n170 n192 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U182 (n148 n192 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (n133 n177 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n127 n4 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U194 (n133 n4 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U185 (n127 n177 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U90 (n58 n2 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U92 (n223 n228 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (n60 n59 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U164 (n223 n229 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U171 (n146 n145 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U170 (n178 n179 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U166 (n141 n142 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U163 (n138 n205 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U96 (n223 n61 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U102 (n72 n73 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U158 (n189 n135 N174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U41 (n220 n166 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    Thru58 (data_from_spi\<0\> data_mem\<0\>) iprobe
    Thru57 (data_from_spi\<1\> data_mem\<1\>) iprobe
    Thru56 (data_from_spi\<2\> data_mem\<2\>) iprobe
    Thru55 (data_from_spi\<3\> data_mem\<3\>) iprobe
    Thru54 (data_from_spi\<4\> data_mem\<4\>) iprobe
    Thru53 (data_from_spi\<5\> data_mem\<5\>) iprobe
    Thru52 (data_from_spi\<6\> data_mem\<6\>) iprobe
    Thru51 (data_from_spi\<7\> data_mem\<7\>) iprobe
    Thru50 (data_from_spi\<8\> data_mem\<8\>) iprobe
    Thru49 (data_from_spi\<9\> data_mem\<9\>) iprobe
    Thru48 (data_from_spi\<10\> data_mem\<10\>) iprobe
    Thru47 (data_from_spi\<11\> data_mem\<11\>) iprobe
    Thru46 (data_from_spi\<12\> data_mem\<12\>) iprobe
    Thru45 (data_from_spi\<13\> data_mem\<13\>) iprobe
    Thru44 (data_from_spi\<14\> data_mem\<14\>) iprobe
    Thru43 (data_from_spi\<15\> data_mem\<15\>) iprobe
    Thru42 (data_from_spi\<16\> data_mem\<16\>) iprobe
    Thru41 (data_from_spi\<17\> data_mem\<17\>) iprobe
    Thru40 (data_from_spi\<18\> data_mem\<18\>) iprobe
    Thru39 (data_from_spi\<19\> data_mem\<19\>) iprobe
    Thru38 (data_from_spi\<20\> data_mem\<20\>) iprobe
    Thru37 (data_from_spi\<21\> data_mem\<21\>) iprobe
    Thru36 (data_from_spi\<22\> data_mem\<22\>) iprobe
    Thru35 (data_from_spi\<23\> data_mem\<23\>) iprobe
    Thru34 (data_from_spi\<24\> data_mem\<24\>) iprobe
    Thru33 (data_from_spi\<25\> data_mem\<25\>) iprobe
    Thru32 (data_from_spi\<26\> data_mem\<26\>) iprobe
    Thru31 (data_from_spi\<27\> data_mem\<27\>) iprobe
    Thru30 (data_from_spi\<28\> data_mem\<28\>) iprobe
    Thru29 (data_from_spi\<29\> data_mem\<29\>) iprobe
    Thru28 (data_from_spi\<30\> data_mem\<30\>) iprobe
    Thru27 (data_from_spi\<31\> data_mem\<31\>) iprobe
    Thru26 (GND! data_to_spi\<2\>) iprobe
    Thru25 (GND! data_to_spi\<3\>) iprobe
    Thru24 (GND! data_to_spi\<4\>) iprobe
    Thru23 (GND! data_to_spi\<5\>) iprobe
    Thru22 (GND! data_to_spi\<6\>) iprobe
    Thru21 (GND! data_to_spi\<7\>) iprobe
    Thru20 (GND! data_to_spi\<8\>) iprobe
    Thru19 (GND! data_to_spi\<9\>) iprobe
    Thru18 (GND! data_to_spi\<10\>) iprobe
    Thru17 (GND! data_to_spi\<11\>) iprobe
    Thru16 (GND! data_to_spi\<12\>) iprobe
    Thru15 (GND! data_to_spi\<13\>) iprobe
    Thru14 (GND! data_to_spi\<14\>) iprobe
    Thru13 (GND! data_to_spi\<15\>) iprobe
    Thru12 (GND! data_to_spi\<16\>) iprobe
    Thru11 (GND! data_to_spi\<17\>) iprobe
    Thru10 (GND! data_to_spi\<18\>) iprobe
    Thru9 (GND! data_to_spi\<19\>) iprobe
    Thru8 (GND! data_to_spi\<20\>) iprobe
    Thru7 (GND! data_to_spi\<21\>) iprobe
    Thru6 (GND! data_to_spi\<22\>) iprobe
    Thru5 (GND! data_to_spi\<23\>) iprobe
    Thru4 (GND! data_to_spi\<27\>) iprobe
    Thru3 (GND! data_to_spi\<28\>) iprobe
    Thru2 (GND! data_to_spi\<29\>) iprobe
    Thru1 (GND! data_to_spi\<30\>) iprobe
    Thru0 (GND! data_to_spi\<31\>) iprobe
ends soc_no_opt_16may_spi_startup_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: soc_top
// View name: schematic
subckt soc_top clk d_clk nreset pass fail sclk \
        miso mosi cs1 cs2 cs3 cs4 skip_startup d_clk_out \
        instr_mem_write_en instr_mem_Address\<10\> instr_mem_Address\<9\> \
        instr_mem_Address\<8\> instr_mem_Address\<7\> \
        instr_mem_Address\<6\> instr_mem_Address\<5\> \
        instr_mem_Address\<4\> instr_mem_Address\<3\> \
        instr_mem_Address\<2\> instr_mem_Address\<1\> \
        instr_mem_Address\<0\> instr_mem_write_data_input\<31\> \
        instr_mem_write_data_input\<30\> instr_mem_write_data_input\<29\> \
        instr_mem_write_data_input\<28\> instr_mem_write_data_input\<27\> \
        instr_mem_write_data_input\<26\> instr_mem_write_data_input\<25\> \
        instr_mem_write_data_input\<24\> instr_mem_write_data_input\<23\> \
        instr_mem_write_data_input\<22\> instr_mem_write_data_input\<21\> \
        instr_mem_write_data_input\<20\> instr_mem_write_data_input\<19\> \
        instr_mem_write_data_input\<18\> instr_mem_write_data_input\<17\> \
        instr_mem_write_data_input\<16\> instr_mem_write_data_input\<15\> \
        instr_mem_write_data_input\<14\> instr_mem_write_data_input\<13\> \
        instr_mem_write_data_input\<12\> instr_mem_write_data_input\<11\> \
        instr_mem_write_data_input\<10\> instr_mem_write_data_input\<9\> \
        instr_mem_write_data_input\<8\> instr_mem_write_data_input\<7\> \
        instr_mem_write_data_input\<6\> instr_mem_write_data_input\<5\> \
        instr_mem_write_data_input\<4\> instr_mem_write_data_input\<3\> \
        instr_mem_write_data_input\<2\> instr_mem_write_data_input\<1\> \
        instr_mem_write_data_input\<0\> instr_mem_read_data\<31\> \
        instr_mem_read_data\<30\> instr_mem_read_data\<29\> \
        instr_mem_read_data\<28\> instr_mem_read_data\<27\> \
        instr_mem_read_data\<26\> instr_mem_read_data\<25\> \
        instr_mem_read_data\<24\> instr_mem_read_data\<23\> \
        instr_mem_read_data\<22\> instr_mem_read_data\<21\> \
        instr_mem_read_data\<20\> instr_mem_read_data\<19\> \
        instr_mem_read_data\<18\> instr_mem_read_data\<17\> \
        instr_mem_read_data\<16\> instr_mem_read_data\<15\> \
        instr_mem_read_data\<14\> instr_mem_read_data\<13\> \
        instr_mem_read_data\<12\> instr_mem_read_data\<11\> \
        instr_mem_read_data\<10\> instr_mem_read_data\<9\> \
        instr_mem_read_data\<8\> instr_mem_read_data\<7\> \
        instr_mem_read_data\<6\> instr_mem_read_data\<5\> \
        instr_mem_read_data\<4\> instr_mem_read_data\<3\> \
        instr_mem_read_data\<2\> instr_mem_read_data\<1\> \
        instr_mem_read_data\<0\> instr_mem_reset_pulse_generator \
        instr_mem_idle data_mem_write_en data_mem_Address\<10\> \
        data_mem_Address\<9\> data_mem_Address\<8\> data_mem_Address\<7\> \
        data_mem_Address\<6\> data_mem_Address\<5\> data_mem_Address\<4\> \
        data_mem_Address\<3\> data_mem_Address\<2\> data_mem_Address\<1\> \
        data_mem_Address\<0\> data_mem_write_data_input\<31\> \
        data_mem_write_data_input\<30\> data_mem_write_data_input\<29\> \
        data_mem_write_data_input\<28\> data_mem_write_data_input\<27\> \
        data_mem_write_data_input\<26\> data_mem_write_data_input\<25\> \
        data_mem_write_data_input\<24\> data_mem_write_data_input\<23\> \
        data_mem_write_data_input\<22\> data_mem_write_data_input\<21\> \
        data_mem_write_data_input\<20\> data_mem_write_data_input\<19\> \
        data_mem_write_data_input\<18\> data_mem_write_data_input\<17\> \
        data_mem_write_data_input\<16\> data_mem_write_data_input\<15\> \
        data_mem_write_data_input\<14\> data_mem_write_data_input\<13\> \
        data_mem_write_data_input\<12\> data_mem_write_data_input\<11\> \
        data_mem_write_data_input\<10\> data_mem_write_data_input\<9\> \
        data_mem_write_data_input\<8\> data_mem_write_data_input\<7\> \
        data_mem_write_data_input\<6\> data_mem_write_data_input\<5\> \
        data_mem_write_data_input\<4\> data_mem_write_data_input\<3\> \
        data_mem_write_data_input\<2\> data_mem_write_data_input\<1\> \
        data_mem_write_data_input\<0\> data_mem_read_data\<31\> \
        data_mem_read_data\<30\> data_mem_read_data\<29\> \
        data_mem_read_data\<28\> data_mem_read_data\<27\> \
        data_mem_read_data\<26\> data_mem_read_data\<25\> \
        data_mem_read_data\<24\> data_mem_read_data\<23\> \
        data_mem_read_data\<22\> data_mem_read_data\<21\> \
        data_mem_read_data\<20\> data_mem_read_data\<19\> \
        data_mem_read_data\<18\> data_mem_read_data\<17\> \
        data_mem_read_data\<16\> data_mem_read_data\<15\> \
        data_mem_read_data\<14\> data_mem_read_data\<13\> \
        data_mem_read_data\<12\> data_mem_read_data\<11\> \
        data_mem_read_data\<10\> data_mem_read_data\<9\> \
        data_mem_read_data\<8\> data_mem_read_data\<7\> \
        data_mem_read_data\<6\> data_mem_read_data\<5\> \
        data_mem_read_data\<4\> data_mem_read_data\<3\> \
        data_mem_read_data\<2\> data_mem_read_data\<1\> \
        data_mem_read_data\<0\> data_mem_be\<1\> data_mem_be\<0\> \
        data_mem_reset_pulse_generator data_mem_idle  
    U363 (startup_data_we n459 n360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U361 (n360 n361 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U362 (cpu_data_we n465 n361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (startup_instr_we n459 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (startup_spi_clear n459 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (startup_spi_settings n459 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (startup_spi_start n459 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n89 n596 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n87 n88 spi_clear inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n86 n596 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n84 n85 spi_settings inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (n83 n657 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n81 n82 spi_start inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n624 n95 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n512 n592 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U575 (n432 n433 cpu_sleep inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U265 (spi_busy n186 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (timer\<0\> n451 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (timer\<1\> n451 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n238 n239 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n234 n624 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (startup_spi_data_out\<0\> n102 n230 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U578 (n434 n435 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U597 (cpu_data_addr\<10\> cpu_data_addr\<11\> n443 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U596 (cpu_data_addr\<9\> cpu_data_addr\<7\> n444 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U580 (data_addr\<4\> startup_done n437 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U584 (data_addr\<5\> n655 n436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U588 (data_addr\<8\> data_addr\<6\> n440 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U257 (timer\<32\> n453 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (timer\<33\> n453 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U256 (n230 n231 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n186 startup_spi_finished n185 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U202 (n184 n185 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (startup_spi_data_out\<1\> n598 n182 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U199 (n182 n183 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U271 (n657 n240 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U570 (cpu_data_addr\<1\> n465 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n593 n624 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U366 (startup_data_mem\<9\> n459 n244 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U364 (n297 n244 data_data_w\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U365 (cpu_spi_data_in\<9\> startup_done n297 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U369 (startup_data_mem\<8\> n459 n245 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U367 (n299 n245 data_data_w\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U368 (cpu_spi_data_in\<8\> startup_done n299 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U372 (startup_data_mem\<7\> n459 n246 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U370 (n246 n301 data_data_w\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U371 (cpu_spi_data_in\<7\> n465 n301 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U375 (startup_data_mem\<6\> n459 n247 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U373 (n247 n303 data_data_w\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U374 (cpu_spi_data_in\<6\> n465 n303 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U378 (startup_data_mem\<5\> n459 n248 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U376 (n248 n305 data_data_w\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U377 (cpu_spi_data_in\<5\> startup_done n305 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U381 (startup_data_mem\<4\> n459 n249 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U379 (n249 n307 data_data_w\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U380 (cpu_spi_data_in\<4\> n465 n307 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U384 (startup_data_mem\<3\> n459 n250 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U382 (n250 n309 data_data_w\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U383 (cpu_spi_data_in\<3\> n465 n309 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U387 (startup_data_mem\<31\> n459 n251 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U385 (n251 n311 data_data_w\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U464 (data_mem_data_r\<8\> n479 n365 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U574 (cpu_data_addr\<0\> n465 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U463 (n364 n365 data_data_r\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U465 (n458 n497 n364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U599 (nreset pass_i n446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U598 (nreset fail_i n445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U322 (n322 n323 data_to_spi\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U323 (startup_spi_data_in\<26\> n459 n322 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U324 (n324 n325 data_to_spi\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (startup_spi_data_in\<25\> n459 n324 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U326 (n326 n327 data_to_spi\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (startup_spi_data_in\<24\> n459 n326 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U336 (n336 n337 data_to_spi\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (startup_spi_data_in\<1\> n459 n336 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U359 (startup_spi_data_in\<0\> n459 n358 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U358 (n358 n359 data_to_spi\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U386 (cpu_spi_data_in\<31\> startup_done n311 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U557 (cpu_data_be\<0\> startup_done n426 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U556 (n659 startup_done data_be\[1\] inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U292 (cpu_instr_addr\<1\> startup_done n292 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U295 (cpu_instr_addr\<0\> n465 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U390 (startup_data_mem\<30\> n459 n252 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U388 (n313 n252 data_data_w\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U389 (cpu_spi_data_in\<30\> startup_done n313 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U393 (startup_data_mem\<2\> n459 n253 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U391 (n253 n315 data_data_w\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U392 (cpu_spi_data_in\<2\> n465 n315 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U396 (startup_data_mem\<29\> n459 n254 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U394 (n254 n317 data_data_w\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U395 (cpu_spi_data_in\<29\> n465 n317 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U399 (startup_data_mem\<28\> n459 n255 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U397 (n255 n319 data_data_w\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U398 (cpu_spi_data_in\<28\> n465 n319 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U402 (startup_data_mem\<27\> n459 n256 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U400 (n256 n321 data_data_w\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U401 (cpu_spi_data_in\<27\> n465 n321 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U405 (startup_data_mem\<26\> n459 n257 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U403 (n257 n323 data_data_w\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U404 (cpu_spi_data_in\<26\> n465 n323 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U408 (startup_data_mem\<25\> n459 n258 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U406 (n258 n325 data_data_w\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U407 (cpu_spi_data_in\<25\> startup_done n325 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U411 (startup_data_mem\<24\> n459 n259 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U409 (n259 n327 data_data_w\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U410 (cpu_spi_data_in\<24\> n465 n327 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U414 (startup_data_mem\<23\> n459 n260 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U412 (n260 n329 data_data_w\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U413 (cpu_spi_data_in\<23\> n465 n329 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U417 (startup_data_mem\<22\> n459 n261 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U415 (n261 n331 data_data_w\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U416 (cpu_spi_data_in\<22\> startup_done n331 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U420 (startup_data_mem\<21\> n459 n262 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U418 (n262 n333 data_data_w\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U419 (cpu_spi_data_in\<21\> startup_done n333 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U423 (startup_data_mem\<20\> n459 n263 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U421 (n263 n335 data_data_w\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U422 (cpu_spi_data_in\<20\> startup_done n335 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U426 (startup_data_mem\<1\> n459 n264 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U424 (n264 n337 data_data_w\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U425 (cpu_spi_data_in\<1\> startup_done n337 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U458 (cpu_spi_data_in\<0\> startup_done n359 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U457 (n275 n359 data_data_w\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U459 (startup_data_mem\<0\> n459 n275 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U429 (startup_data_mem\<19\> n459 n265 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U427 (n265 n339 data_data_w\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U428 (cpu_spi_data_in\<19\> n465 n339 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U432 (startup_data_mem\<18\> n459 n266 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U430 (n341 n266 data_data_w\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U431 (cpu_spi_data_in\<18\> startup_done n341 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U435 (startup_data_mem\<17\> n459 n267 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U433 (n343 n267 data_data_w\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U434 (cpu_spi_data_in\<17\> startup_done n343 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U438 (startup_data_mem\<16\> n459 n268 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U436 (n345 n268 data_data_w\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U437 (cpu_spi_data_in\<16\> startup_done n345 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U441 (startup_data_mem\<15\> n459 n269 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U439 (n269 n347 data_data_w\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U440 (cpu_spi_data_in\<15\> startup_done n347 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U444 (startup_data_mem\<14\> n459 n270 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U442 (n270 n349 data_data_w\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U443 (cpu_spi_data_in\<14\> n465 n349 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U447 (startup_data_mem\<13\> n459 n271 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U445 (n271 n351 data_data_w\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U446 (cpu_spi_data_in\<13\> startup_done n351 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U450 (startup_data_mem\<12\> n459 n272 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U448 (n272 n353 data_data_w\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U449 (cpu_spi_data_in\<12\> n465 n353 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U453 (startup_data_mem\<11\> n459 n273 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U456 (startup_data_mem\<10\> n459 n274 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U451 (n273 n355 data_data_w\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U454 (n274 n357 data_data_w\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U455 (cpu_spi_data_in\<10\> startup_done n357 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U452 (startup_done cpu_spi_data_in\<11\> n355 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U253 (timer\<42\> n453 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (timer\<10\> n451 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U250 (n625 n223 mem_data_n\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (startup_spi_data_out\<10\> n500 n223 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U251 (n225 n226 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (startup_spi_data_out\<11\> n598 n219 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U245 (n219 n626 mem_data_n\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U248 (timer\<43\> n453 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U247 (timer\<11\> n451 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n221 n222 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (n598 startup_spi_data_out\<12\> n215 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U240 (n627 n215 mem_data_n\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (timer\<44\> n453 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (timer\<12\> n451 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U241 (n217 n218 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (startup_spi_data_out\<13\> n517 n211 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U235 (n211 n628 mem_data_n\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U238 (timer\<45\> n453 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (timer\<13\> n451 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n213 n214 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n597 startup_spi_data_out\<14\> n207 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U230 (n629 n207 mem_data_n\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (timer\<46\> n453 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U232 (timer\<14\> n451 n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n209 n210 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (n102 startup_spi_data_out\<15\> n203 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U225 (n630 n203 mem_data_n\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (timer\<47\> n453 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (timer\<15\> n451 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (n205 n206 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (n597 startup_spi_data_out\<16\> n199 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U220 (n199 n631 mem_data_n\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U592 (n442 n278 data_addr\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U593 (cpu_data_addr\<8\> n465 n442 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U278 (n278 n279 instr_addr\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (cpu_instr_addr\<8\> n465 n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U590 (cpu_data_addr\<6\> n465 n441 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U589 (n441 n282 data_addr\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U282 (n282 n283 instr_addr\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U283 (cpu_instr_addr\<6\> n465 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U585 (n439 n284 data_addr\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U586 (cpu_data_addr\<5\> startup_done n439 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U284 (n284 n285 instr_addr\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U285 (cpu_instr_addr\<5\> n465 n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U582 (cpu_data_addr\<4\> startup_done n438 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U581 (n438 n286 data_addr\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U286 (n286 n287 instr_addr\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U287 (cpu_instr_addr\<4\> n465 n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U572 (cpu_data_addr\<10\> startup_done n431 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U571 (n431 n293 data_addr\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (n293 n294 instr_addr\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U294 (cpu_instr_addr\<10\> n465 n294 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U568 (cpu_data_addr\<2\> n465 n430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U567 (n430 n290 data_addr\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U290 (n291 n290 instr_addr\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U291 (cpu_instr_addr\<2\> n465 n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U565 (cpu_data_addr\<3\> n465 n429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U564 (n429 n288 data_addr\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U288 (n288 n289 instr_addr\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U289 (cpu_instr_addr\<3\> startup_done n289 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U559 (cpu_data_addr\<9\> startup_done n427 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U558 (n427 n276 data_addr\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U562 (cpu_data_addr\<7\> n465 n428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U561 (n428 n280 data_addr\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U280 (n280 n281 instr_addr\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (cpu_instr_addr\<7\> n465 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n276 n277 instr_addr\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (cpu_instr_addr\<9\> n465 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U594 (startup_instr_addr\<8\> n459 n278 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U591 (startup_instr_addr\<6\> n459 n282 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U587 (startup_instr_addr\<5\> n459 n284 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U583 (startup_instr_addr\<4\> n459 n286 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U573 (startup_instr_addr\<10\> n459 n293 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U569 (startup_instr_addr\<2\> n459 n290 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U566 (startup_instr_addr\<3\> n459 n288 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U563 (startup_instr_addr\<7\> n459 n280 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U560 (startup_instr_addr\<9\> n459 n276 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U218 (timer\<49\> n453 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (timer\<17\> n451 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n632 n195 mem_data_n\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n517 startup_spi_data_out\<17\> n195 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U216 (n197 n198 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (timer\<51\> n453 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (timer\<19\> n451 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U205 (n634 n187 mem_data_n\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (n598 startup_spi_data_out\<19\> n187 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U206 (n189 n190 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (timer\<52\> n453 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (timer\<20\> n451 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n175 n635 mem_data_n\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n597 startup_spi_data_out\<20\> n175 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U194 (n177 n178 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U555 (n498 mem_data_seq\<0\> n424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U553 (n424 n425 data_data_r\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U554 (data_mem_data_r\<0\> n466 n425 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U497 (data_mem_data_r\<27\> n1 n387 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U496 (n386 n387 data_data_r\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U498 (n609 mem_data_seq\<27\> n386 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U470 (data_mem_data_r\<6\> n479 n369 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U469 (n368 n369 data_data_r\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U471 (n460 mem_data_seq\<6\> n368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U552 (n460 mem_data_seq\<10\> n422 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U550 (n422 n423 data_data_r\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U551 (data_mem_data_r\<10\> n461 n423 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U549 (n460 mem_data_seq\<11\> n420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U547 (n420 n421 data_data_r\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U548 (data_mem_data_r\<11\> n467 n421 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U515 (data_mem_data_r\<21\> n461 n399 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U514 (n398 n399 data_data_r\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U516 (n607 mem_data_seq\<21\> n398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U546 (n608 mem_data_seq\<12\> n418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U544 (n418 n419 data_data_r\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U545 (data_mem_data_r\<12\> n490 n419 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U542 (data_mem_data_r\<13\> n490 n417 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U541 (n416 n417 data_data_r\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U543 (n515 mem_data_seq\<13\> n416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U540 (n514 mem_data_seq\<14\> n414 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U538 (n414 n415 data_data_r\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U539 (data_mem_data_r\<14\> n467 n415 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U503 (data_mem_data_r\<25\> n467 n391 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U502 (n390 n391 data_data_r\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U504 (n468 mem_data_seq\<25\> n390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U537 (n609 mem_data_seq\<15\> n412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U535 (n412 n413 data_data_r\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U536 (data_mem_data_r\<15\> n472 n413 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U495 (n609 mem_data_seq\<28\> n384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U493 (n384 n385 data_data_r\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U494 (data_mem_data_r\<28\> n462 n385 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U479 (data_mem_data_r\<3\> n472 n375 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U478 (n374 n375 data_data_r\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U480 (n498 mem_data_seq\<3\> n374 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U501 (n498 mem_data_seq\<26\> n388 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U499 (n388 n389 data_data_r\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U500 (data_mem_data_r\<26\> n473 n389 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U534 (n468 mem_data_seq\<16\> n410 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U532 (n410 n411 data_data_r\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U533 (data_mem_data_r\<16\> n462 n411 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U474 (n468 mem_data_seq\<5\> n370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U472 (n370 n371 data_data_r\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U473 (data_mem_data_r\<5\> n478 n371 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U531 (n515 mem_data_seq\<17\> n408 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U529 (n408 n409 data_data_r\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U530 (data_mem_data_r\<17\> n464 n409 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U468 (n515 mem_data_seq\<7\> n366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U466 (n366 n367 data_data_r\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U467 (data_mem_data_r\<7\> n478 n367 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U461 (data_mem_data_r\<9\> n478 n363 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U460 (n362 n363 data_data_r\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U462 (n606 mem_data_seq\<9\> n362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U489 (n606 mem_data_seq\<2\> n380 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U487 (n380 n381 data_data_r\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U488 (data_mem_data_r\<2\> n464 n381 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U509 (data_mem_data_r\<23\> n464 n395 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U508 (n394 n395 data_data_r\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U510 (n516 mem_data_seq\<23\> n394 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U528 (n514 mem_data_seq\<18\> n406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U526 (n406 n407 data_data_r\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U527 (data_mem_data_r\<18\> n463 n407 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U525 (n514 mem_data_seq\<19\> n404 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U523 (n404 n405 data_data_r\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U524 (data_mem_data_r\<19\> n466 n405 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U482 (data_mem_data_r\<31\> n466 n377 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U481 (n376 n377 data_data_r\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U483 (n497 mem_data_seq\<31\> n376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U477 (n497 mem_data_seq\<4\> n372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U475 (n372 n373 data_data_r\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U476 (data_mem_data_r\<4\> n462 n373 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U522 (n608 mem_data_seq\<1\> n402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U520 (n402 n403 data_data_r\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U521 (data_mem_data_r\<1\> n473 n403 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U518 (data_mem_data_r\<20\> n473 n401 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U517 (n400 n401 data_data_r\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U519 (n607 mem_data_seq\<20\> n400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U492 (n608 mem_data_seq\<29\> n382 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U490 (n382 n383 data_data_r\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U491 (data_mem_data_r\<29\> n462 n383 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U512 (data_mem_data_r\<22\> n462 n397 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U511 (n396 n397 data_data_r\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U513 (n516 mem_data_seq\<22\> n396 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U507 (n516 mem_data_seq\<24\> n392 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U505 (n392 n393 data_data_r\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U506 (data_mem_data_r\<24\> n463 n393 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U486 (n607 mem_data_seq\<30\> n378 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U484 (n378 n379 data_data_r\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U485 (data_mem_data_r\<30\> n463 n379 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U223 (timer\<48\> n453 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (n201 n202 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (timer\<16\> n451 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (timer\<50\> n453 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (n193 n194 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (timer\<18\> n451 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n633 n191 mem_data_n\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (startup_spi_data_out\<18\> n471 n191 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U192 (startup_spi_data_out\<21\> n471 n171 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U188 (n636 n171 mem_data_n\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (timer\<54\> n453 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (timer\<22\> n451 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (n167 n637 mem_data_n\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n517 startup_spi_data_out\<22\> n167 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U184 (n169 n170 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (timer\<55\> n453 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n165 n166 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U180 (timer\<23\> n451 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n163 n638 mem_data_n\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n597 startup_spi_data_out\<23\> n163 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U107 (n597 startup_spi_data_out\<8\> n103 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U103 (n103 n653 mem_data_n\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (timer\<40\> n453 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (timer\<8\> n451 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n105 n106 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n517 startup_spi_data_out\<24\> n159 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U173 (n159 n639 mem_data_n\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (timer\<56\> n453 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (timer\<24\> n451 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (n161 n162 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (startup_spi_data_out\<28\> n517 n143 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U153 (n143 n643 mem_data_n\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (timer\<60\> n453 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (timer\<28\> n451 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n145 n146 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (timer\<57\> n453 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (timer\<25\> n451 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (n155 n640 mem_data_n\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n471 startup_spi_data_out\<25\> n155 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U169 (n157 n158 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (timer\<58\> n453 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n153 n154 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (timer\<26\> n451 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n151 n641 mem_data_n\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (startup_spi_data_out\<26\> n598 n151 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U117 (startup_spi_data_out\<6\> n598 n111 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U113 (n111 n651 mem_data_n\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (timer\<38\> n453 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (timer\<6\> n451 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n113 n114 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n471 startup_spi_data_out\<27\> n147 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U158 (n147 n642 mem_data_n\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (timer\<59\> n453 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (timer\<27\> n451 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n149 n150 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (timer\<61\> n453 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (timer\<29\> n451 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n139 n644 mem_data_n\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (startup_spi_data_out\<29\> n500 n139 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U149 (n141 n142 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n500 startup_spi_data_out\<2\> n135 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U143 (n135 n645 mem_data_n\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (timer\<34\> n453 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (timer\<2\> n451 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n137 n138 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n500 startup_spi_data_out\<30\> n131 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U138 (n646 n131 mem_data_n\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (timer\<62\> n453 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (timer\<30\> n451 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (n133 n134 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (timer\<63\> n453 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n129 n130 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (timer\<31\> n451 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n647 n127 mem_data_n\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (startup_spi_data_out\<31\> n102 n127 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U122 (startup_spi_data_out\<5\> n102 n115 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U118 (n115 n650 mem_data_n\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (timer\<37\> n453 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (timer\<5\> n451 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n117 n118 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (startup_spi_data_out\<3\> n471 n123 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U128 (n648 n123 mem_data_n\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (timer\<35\> n453 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (timer\<3\> n451 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n125 n126 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (startup_spi_data_out\<9\> n471 n96 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U98 (n96 n654 mem_data_n\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (timer\<41\> n453 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (timer\<9\> n451 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n98 n99 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (startup_spi_data_out\<4\> n500 n119 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U123 (n119 n649 mem_data_n\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (timer\<36\> n453 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (timer\<4\> n451 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n121 n122 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (startup_spi_data_out\<7\> n500 n107 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U108 (n107 n652 mem_data_n\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (timer\<39\> n453 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n109 n110 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (timer\<7\> n451 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (timer\<53\> n453 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (n173 n174 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (timer\<21\> n451 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U799 (n242 instr_we inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U600 (n465 n448 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U834 (n440 n655 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U740 (data_mem_we n584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U741 (n584 n585 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U601 (n91 n449 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U835 (n237 n656 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U656 (n592 n501 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U669 (n512 n513 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U616 (n459 n465 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U608 (startup_done n459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U836 (n90 n657 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U802 (n95 n621 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U750 (n592 n593 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U749 (data_addr\<2\> n592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U668 (n657 n512 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U803 (n241 n624 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U871 (n244 n694 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U772 (n297 data_to_spi\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U870 (n245 n693 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U773 (n299 data_to_spi\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U869 (n246 n692 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U774 (n301 data_to_spi\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U868 (n247 n691 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U775 (n303 data_to_spi\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U867 (n248 n690 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U776 (n305 data_to_spi\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U866 (n249 n689 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U777 (n307 data_to_spi\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U865 (n250 n688 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U778 (n309 data_to_spi\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U864 (n251 n687 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U769 (n696 n616 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U768 (n616 data_mem_reset_pulse_generator inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_invx2_PB4_AFBB
    U752 (n233 n595 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U771 (n695 n618 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U770 (n618 instr_mem_reset_pulse_generator inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_invx2_PB4_AFBB
    U753 (n233 n596 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U602 (n100 n450 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U603 (n450 n451 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U837 (n233 n658 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U751 (n658 n594 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U604 (n101 n452 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U605 (n452 n453 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U666 (n456 n511 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U606 (n511 n454 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U665 (n454 pass inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U747 (n457 n591 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U607 (n591 n455 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U746 (n455 fail inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U767 (n447 n614 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U779 (n311 data_to_spi\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U839 (n426 n660 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U838 (cpu_data_be\<1\> n659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U801 (n292 n620 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U800 (n295 n619 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U863 (n252 n686 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U780 (n313 data_to_spi\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U862 (n253 n685 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U781 (n315 data_to_spi\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U861 (n254 n684 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U782 (n317 data_to_spi\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U860 (n255 n683 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U783 (n319 data_to_spi\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U859 (n256 n682 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U784 (n321 data_to_spi\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U858 (n257 n681 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U857 (n258 n680 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U856 (n259 n679 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U855 (n260 n678 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U785 (n329 data_to_spi\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U854 (n261 n677 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U786 (n331 data_to_spi\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U853 (n262 n676 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U787 (n333 data_to_spi\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U852 (n263 n675 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U788 (n335 data_to_spi\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U851 (n264 n674 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U840 (n275 n663 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U850 (n265 n673 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U789 (n339 data_to_spi\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U849 (n266 n672 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U790 (n341 data_to_spi\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U848 (n267 n671 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U791 (n343 data_to_spi\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U847 (n268 n670 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U792 (n345 data_to_spi\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U846 (n269 n669 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U793 (n347 data_to_spi\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U845 (n270 n668 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U794 (n349 data_to_spi\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U844 (n271 n667 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U795 (n351 data_to_spi\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U843 (n272 n666 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U796 (n353 data_to_spi\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U842 (n273 n665 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U841 (n274 n664 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U798 (n357 data_to_spi\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U797 (n355 data_to_spi\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U804 (n224 n625 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U655 (n599 n500 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U805 (n220 n626 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U806 (n216 n627 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U673 (n599 n517 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U807 (n212 n628 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U808 (n208 n629 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U756 (n102 n599 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U809 (n204 n630 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U810 (n200 n631 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U744 (data_addr\<8\> n588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U745 (n588 n589 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U743 (n586 n587 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U742 (data_addr\<4\> n586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U739 (n582 n583 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U738 (data_data_w\<0\> n582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U737 (n580 n581 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U736 (data_data_w\<1\> n580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U735 (n578 n579 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U734 (data_data_w\<2\> n578 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U733 (n576 n577 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U732 (data_data_w\<3\> n576 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U731 (n574 n575 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U730 (data_data_w\<4\> n574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U729 (n572 n573 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U728 (data_data_w\<5\> n572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U727 (n570 n571 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U726 (data_data_w\<6\> n570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U725 (n568 n569 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U724 (data_data_w\<7\> n568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U723 (n566 n567 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U722 (data_data_w\<8\> n566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U721 (n564 n565 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U720 (data_data_w\<9\> n564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U719 (n562 n563 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U718 (data_data_w\<10\> n562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U717 (n560 n561 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U716 (data_data_w\<11\> n560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U715 (n558 n559 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U714 (data_data_w\<12\> n558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U713 (n556 n557 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U712 (data_data_w\<13\> n556 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U711 (n554 n555 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U710 (data_data_w\<14\> n554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U709 (n552 n553 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U708 (data_data_w\<15\> n552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U707 (n550 n551 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U706 (data_data_w\<16\> n550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U705 (n548 n549 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U704 (data_data_w\<17\> n548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U703 (n546 n547 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U702 (data_data_w\<18\> n546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U701 (n544 n545 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U700 (data_data_w\<19\> n544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U699 (n542 n543 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U698 (data_data_w\<20\> n542 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U697 (n540 n541 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U696 (data_data_w\<21\> n540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U695 (n538 n539 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U694 (data_data_w\<22\> n538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U693 (n536 n537 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U692 (data_data_w\<23\> n536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U691 (n534 n535 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U690 (data_data_w\<24\> n534 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U689 (n532 n533 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U688 (data_data_w\<25\> n532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U687 (n530 n531 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U686 (data_data_w\<26\> n530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U685 (n528 n529 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U684 (data_data_w\<27\> n528 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U683 (n526 n527 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U682 (data_data_w\<28\> n526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U681 (n524 n525 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U680 (data_data_w\<29\> n524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U679 (n522 n523 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U678 (data_data_w\<30\> n522 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U677 (n520 n521 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U676 (data_data_w\<31\> n520 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U674 (instr_addr\<3\> n518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U675 (n518 n519 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U664 (n508 n509 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U663 (data_addr\<5\> n508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U662 (n506 n507 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U661 (data_addr\<7\> n506 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U660 (n504 n505 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U659 (instr_addr\<2\> n504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U658 (n502 n503 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U657 (instr_addr\<10\> n502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U651 (n495 n496 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U650 (data_addr\<6\> n495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U649 (n493 n494 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U648 (data_addr\<9\> n493 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U647 (n491 n492 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U646 (instr_addr\<4\> n491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U642 (n487 n488 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U641 (data_addr\<3\> n487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U637 (n482 n483 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U636 (data_addr\<10\> n482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U640 (n485 n486 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U639 (instr_addr\<5\> n485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U635 (n480 n481 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U634 (instr_addr\<6\> n480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U630 (n476 n477 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U629 (instr_addr\<7\> n476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U628 (n474 n475 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U627 (instr_addr\<9\> n474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U622 (n469 n470 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U621 (instr_addr\<8\> n469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U755 (n599 n598 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U754 (n599 n597 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U623 (n599 n471 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U811 (n196 n632 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U813 (n188 n634 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U814 (n176 n635 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U758 (n1 n605 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U633 (n600 n479 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U815 (n172 n636 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U812 (n192 n633 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U653 (n610 n498 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U763 (n612 n610 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U761 (n610 n608 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U765 (n613 n612 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U764 (n612 n611 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U766 (n468 n613 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U652 (n613 n497 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U759 (n611 n606 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U671 (n611 n515 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U645 (n606 n490 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U620 (n472 n468 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U625 (n601 n472 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U626 (n601 n473 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U624 (n604 n601 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U757 (n605 n604 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U614 (n604 n603 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U638 (n605 n484 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U762 (n499 n609 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U670 (n499 n514 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U654 (n607 n499 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U609 (n499 n460 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U760 (n462 n607 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U631 (n484 n600 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U617 (n484 n602 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U618 (n602 n466 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U619 (n602 n467 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U632 (n600 n478 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U615 (n603 n464 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U613 (n603 n463 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U612 (n489 n462 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U611 (n490 n489 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U610 (n489 n461 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U672 (n461 n516 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U816 (n168 n637 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U832 (n104 n653 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U817 (n164 n638 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U818 (n160 n639 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U822 (n144 n643 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U819 (n156 n640 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U830 (n112 n651 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U820 (n152 n641 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U821 (n148 n642 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U823 (n140 n644 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U824 (n136 n645 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U825 (n132 n646 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U829 (n116 n650 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U826 (n128 n647 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U827 (n124 n648 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U833 (n97 n654 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U828 (n120 n649 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U831 (n108 n652 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    mem_data_seq_reg_0_ (d_clk_out n622 mem_data_seq\<0\> NeTt_2324 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_1_ (d_clk_out n623 mem_data_seq\<1\> NeTt_2325 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_src_reg (d_clk_out n624 NeTt_2326 n1 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_31_ (d_clk_out mem_data_n\<31\> mem_data_seq\<31\> \
        NeTt_2327 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_10_ (d_clk_out mem_data_n\<10\> mem_data_seq\<10\> \
        NeTt_2328 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_11_ (d_clk_out mem_data_n\<11\> mem_data_seq\<11\> \
        NeTt_2329 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_12_ (d_clk_out mem_data_n\<12\> mem_data_seq\<12\> \
        NeTt_2330 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_13_ (d_clk_out mem_data_n\<13\> mem_data_seq\<13\> \
        NeTt_2331 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_14_ (d_clk_out mem_data_n\<14\> mem_data_seq\<14\> \
        NeTt_2332 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_15_ (d_clk_out mem_data_n\<15\> mem_data_seq\<15\> \
        NeTt_2333 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_16_ (d_clk_out mem_data_n\<16\> mem_data_seq\<16\> \
        NeTt_2334 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_17_ (d_clk_out mem_data_n\<17\> mem_data_seq\<17\> \
        NeTt_2335 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_18_ (d_clk_out mem_data_n\<18\> mem_data_seq\<18\> \
        NeTt_2336 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_19_ (d_clk_out mem_data_n\<19\> mem_data_seq\<19\> \
        NeTt_2337 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_20_ (d_clk_out mem_data_n\<20\> mem_data_seq\<20\> \
        NeTt_2338 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_21_ (d_clk_out mem_data_n\<21\> mem_data_seq\<21\> \
        NeTt_2339 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_22_ (d_clk_out mem_data_n\<22\> mem_data_seq\<22\> \
        NeTt_2340 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_23_ (d_clk_out mem_data_n\<23\> mem_data_seq\<23\> \
        NeTt_2341 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_24_ (d_clk_out mem_data_n\<24\> mem_data_seq\<24\> \
        NeTt_2342 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_25_ (d_clk_out mem_data_n\<25\> mem_data_seq\<25\> \
        NeTt_2343 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_26_ (d_clk_out mem_data_n\<26\> mem_data_seq\<26\> \
        NeTt_2344 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_27_ (d_clk_out mem_data_n\<27\> mem_data_seq\<27\> \
        NeTt_2345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_28_ (d_clk_out mem_data_n\<28\> mem_data_seq\<28\> \
        NeTt_2346 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_29_ (d_clk_out mem_data_n\<29\> mem_data_seq\<29\> \
        NeTt_2347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_2_ (d_clk_out mem_data_n\<2\> mem_data_seq\<2\> \
        NeTt_2348 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_30_ (d_clk_out mem_data_n\<30\> mem_data_seq\<30\> \
        NeTt_2349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_3_ (d_clk_out mem_data_n\<3\> mem_data_seq\<3\> \
        NeTt_2350 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_4_ (d_clk_out mem_data_n\<4\> mem_data_seq\<4\> \
        NeTt_2351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_5_ (d_clk_out mem_data_n\<5\> mem_data_seq\<5\> \
        NeTt_2352 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_6_ (d_clk_out mem_data_n\<6\> mem_data_seq\<6\> \
        NeTt_2353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_7_ (d_clk_out mem_data_n\<7\> mem_data_seq\<7\> \
        NeTt_2354 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_9_ (d_clk_out mem_data_n\<9\> mem_data_seq\<9\> \
        NeTt_2355 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_data_seq_reg_8_ (d_clk_out mem_data_n\<8\> n458 NeTt_2356 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    pass_i_reg_reg (d_clk_out n661 NeTt_2357 n456 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    fail_i_reg_reg (d_clk_out n662 NeTt_2358 n457 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    sync_reset_reg (d_clk_out nreset NeTt_2359 n447 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U644 (n227 n622 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U643 (n179 n623 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U667 (n446 n661 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U748 (n445 n662 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U92 (n90 n449 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U88 (n657 n449 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (n658 n449 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U95 (n94 n93 sleep_we inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U576 (sleep_ctl n511 n433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U577 (n591 n448 n432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U255 (n228 n229 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U263 (n592 n237 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U262 (n657 n593 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U261 (n235 n236 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U595 (n443 n444 n434 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U579 (n437 n436 n435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U198 (n180 n181 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U360 (n624 n621 data_mem_we inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (n92 n621 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U266 (n92 n656 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U272 (n241 n593 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U267 (n657 n596 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U270 (n232 n596 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U258 (n232 n594 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    AAsmund_RISC (d_clk_out n614 cpu_sleep pass_i fail_i \
        cpu_data_addr\<11\> cpu_data_addr\<10\> cpu_data_addr\<9\> \
        cpu_data_addr\<8\> cpu_data_addr\<7\> cpu_data_addr\<6\> \
        cpu_data_addr\<5\> cpu_data_addr\<4\> cpu_data_addr\<3\> \
        cpu_data_addr\<2\> cpu_data_addr\<1\> cpu_data_addr\<0\> \
        data_data_r\<31\> data_data_r\<30\> data_data_r\<29\> \
        data_data_r\<28\> data_data_r\<27\> data_data_r\<26\> \
        data_data_r\<25\> data_data_r\<24\> data_data_r\<23\> \
        data_data_r\<22\> data_data_r\<21\> data_data_r\<20\> \
        data_data_r\<19\> data_data_r\<18\> data_data_r\<17\> \
        data_data_r\<16\> data_data_r\<15\> data_data_r\<14\> \
        data_data_r\<13\> data_data_r\<12\> data_data_r\<11\> \
        data_data_r\<10\> data_data_r\<9\> data_data_r\<8\> \
        data_data_r\<7\> data_data_r\<6\> data_data_r\<5\> \
        data_data_r\<4\> data_data_r\<3\> data_data_r\<2\> \
        data_data_r\<1\> data_data_r\<0\> cpu_data_be\<1\> \
        cpu_data_be\<0\> cpu_spi_data_in\<31\> cpu_spi_data_in\<30\> \
        cpu_spi_data_in\<29\> cpu_spi_data_in\<28\> cpu_spi_data_in\<27\> \
        cpu_spi_data_in\<26\> cpu_spi_data_in\<25\> cpu_spi_data_in\<24\> \
        cpu_spi_data_in\<23\> cpu_spi_data_in\<22\> cpu_spi_data_in\<21\> \
        cpu_spi_data_in\<20\> cpu_spi_data_in\<19\> cpu_spi_data_in\<18\> \
        cpu_spi_data_in\<17\> cpu_spi_data_in\<16\> cpu_spi_data_in\<15\> \
        cpu_spi_data_in\<14\> cpu_spi_data_in\<13\> cpu_spi_data_in\<12\> \
        cpu_spi_data_in\<11\> cpu_spi_data_in\<10\> cpu_spi_data_in\<9\> \
        cpu_spi_data_in\<8\> cpu_spi_data_in\<7\> cpu_spi_data_in\<6\> \
        cpu_spi_data_in\<5\> cpu_spi_data_in\<4\> cpu_spi_data_in\<3\> \
        cpu_spi_data_in\<2\> cpu_spi_data_in\<1\> cpu_spi_data_in\<0\> \
        cpu_data_we NeTt_2361 cpu_instr_addr\<10\> cpu_instr_addr\<9\> \
        cpu_instr_addr\<8\> cpu_instr_addr\<7\> cpu_instr_addr\<6\> \
        cpu_instr_addr\<5\> cpu_instr_addr\<4\> cpu_instr_addr\<3\> \
        cpu_instr_addr\<2\> cpu_instr_addr\<1\> cpu_instr_addr\<0\> \
        instr_data_r\<31\> instr_data_r\<30\> instr_data_r\<29\> \
        instr_data_r\<28\> instr_data_r\<27\> instr_data_r\<26\> \
        instr_data_r\<25\> instr_data_r\<24\> instr_data_r\<23\> \
        instr_data_r\<22\> instr_data_r\<21\> instr_data_r\<20\> \
        instr_data_r\<19\> instr_data_r\<18\> instr_data_r\<17\> \
        instr_data_r\<16\> instr_data_r\<15\> instr_data_r\<14\> \
        instr_data_r\<13\> instr_data_r\<12\> instr_data_r\<11\> \
        instr_data_r\<10\> instr_data_r\<9\> instr_data_r\<8\> \
        instr_data_r\<7\> instr_data_r\<6\> instr_data_r\<5\> \
        instr_data_r\<4\> instr_data_r\<3\> instr_data_r\<2\> \
        instr_data_r\<1\> instr_data_r\<0\> NeTt_2360 inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_top_schematic
    instruction_memory (clk d_clk_out n503 n475 n470 n477 n481 n486 n492 \
        n519 n505 n620 n619 instr_data_r\<31\> instr_data_r\<30\> \
        instr_data_r\<29\> instr_data_r\<28\> instr_data_r\<27\> \
        instr_data_r\<26\> instr_data_r\<25\> instr_data_r\<24\> \
        instr_data_r\<23\> instr_data_r\<22\> instr_data_r\<21\> \
        instr_data_r\<20\> instr_data_r\<19\> instr_data_r\<18\> \
        instr_data_r\<17\> instr_data_r\<16\> instr_data_r\<15\> \
        instr_data_r\<14\> instr_data_r\<13\> instr_data_r\<12\> \
        instr_data_r\<11\> instr_data_r\<10\> instr_data_r\<9\> \
        instr_data_r\<8\> instr_data_r\<7\> instr_data_r\<6\> \
        instr_data_r\<5\> instr_data_r\<4\> instr_data_r\<3\> \
        instr_data_r\<2\> instr_data_r\<1\> instr_data_r\<0\> n687 n686 \
        n684 n683 n682 n681 n680 n679 n678 n677 n676 n675 n673 n672 n671 \
        n670 n669 n668 n667 n666 n665 n664 n694 n693 n692 n691 n690 n689 \
        n688 n685 n674 n663 instr_we n614 NeTt_2362 instr_mem_write_en \
        instr_mem_Address\<10\> instr_mem_Address\<9\> \
        instr_mem_Address\<8\> instr_mem_Address\<7\> \
        instr_mem_Address\<6\> instr_mem_Address\<5\> \
        instr_mem_Address\<4\> instr_mem_Address\<3\> \
        instr_mem_Address\<2\> instr_mem_Address\<1\> \
        instr_mem_Address\<0\> instr_mem_write_data_input\<31\> \
        instr_mem_write_data_input\<30\> instr_mem_write_data_input\<29\> \
        instr_mem_write_data_input\<28\> instr_mem_write_data_input\<27\> \
        instr_mem_write_data_input\<26\> instr_mem_write_data_input\<25\> \
        instr_mem_write_data_input\<24\> instr_mem_write_data_input\<23\> \
        instr_mem_write_data_input\<22\> instr_mem_write_data_input\<21\> \
        instr_mem_write_data_input\<20\> instr_mem_write_data_input\<19\> \
        instr_mem_write_data_input\<18\> instr_mem_write_data_input\<17\> \
        instr_mem_write_data_input\<16\> instr_mem_write_data_input\<15\> \
        instr_mem_write_data_input\<14\> instr_mem_write_data_input\<13\> \
        instr_mem_write_data_input\<12\> instr_mem_write_data_input\<11\> \
        instr_mem_write_data_input\<10\> instr_mem_write_data_input\<9\> \
        instr_mem_write_data_input\<8\> instr_mem_write_data_input\<7\> \
        instr_mem_write_data_input\<6\> instr_mem_write_data_input\<5\> \
        instr_mem_write_data_input\<4\> instr_mem_write_data_input\<3\> \
        instr_mem_write_data_input\<2\> instr_mem_write_data_input\<1\> \
        instr_mem_write_data_input\<0\> instr_mem_read_data\<31\> \
        instr_mem_read_data\<30\> instr_mem_read_data\<29\> \
        instr_mem_read_data\<28\> instr_mem_read_data\<27\> \
        instr_mem_read_data\<26\> instr_mem_read_data\<25\> \
        instr_mem_read_data\<24\> instr_mem_read_data\<23\> \
        instr_mem_read_data\<22\> instr_mem_read_data\<21\> \
        instr_mem_read_data\<20\> instr_mem_read_data\<19\> \
        instr_mem_read_data\<18\> instr_mem_read_data\<17\> \
        instr_mem_read_data\<16\> instr_mem_read_data\<15\> \
        instr_mem_read_data\<14\> instr_mem_read_data\<13\> \
        instr_mem_read_data\<12\> instr_mem_read_data\<11\> \
        instr_mem_read_data\<10\> instr_mem_read_data\<9\> \
        instr_mem_read_data\<8\> instr_mem_read_data\<7\> \
        instr_mem_read_data\<6\> instr_mem_read_data\<5\> \
        instr_mem_read_data\<4\> instr_mem_read_data\<3\> \
        instr_mem_read_data\<2\> instr_mem_read_data\<1\> \
        instr_mem_read_data\<0\> n695 instr_mem_idle inh_gnd inh_gnds \
        inh_vdd inh_vdds) instr_mem_wrap_address_width11
    data_memory (clk d_clk_out data_be\[1\] n660 n483 n494 n589 n507 n496 \
        n509 n587 n488 n501 n513 n595 data_mem_data_r\<31\> \
        data_mem_data_r\<30\> data_mem_data_r\<29\> data_mem_data_r\<28\> \
        data_mem_data_r\<27\> data_mem_data_r\<26\> data_mem_data_r\<25\> \
        data_mem_data_r\<24\> data_mem_data_r\<23\> data_mem_data_r\<22\> \
        data_mem_data_r\<21\> data_mem_data_r\<20\> data_mem_data_r\<19\> \
        data_mem_data_r\<18\> data_mem_data_r\<17\> data_mem_data_r\<16\> \
        data_mem_data_r\<15\> data_mem_data_r\<14\> data_mem_data_r\<13\> \
        data_mem_data_r\<12\> data_mem_data_r\<11\> data_mem_data_r\<10\> \
        data_mem_data_r\<9\> data_mem_data_r\<8\> data_mem_data_r\<7\> \
        data_mem_data_r\<6\> data_mem_data_r\<5\> data_mem_data_r\<4\> \
        data_mem_data_r\<3\> data_mem_data_r\<2\> data_mem_data_r\<1\> \
        data_mem_data_r\<0\> n521 n523 n525 n527 n529 n531 n533 n535 n537 \
        n539 n541 n543 n545 n547 n549 n551 n553 n555 n557 n559 n561 n563 \
        n565 n567 n569 n571 n573 n575 n577 n579 n581 n583 n585 n614 \
        NeTt_2364 data_mem_write_en data_mem_Address\<10\> \
        data_mem_Address\<9\> data_mem_Address\<8\> data_mem_Address\<7\> \
        data_mem_Address\<6\> data_mem_Address\<5\> data_mem_Address\<4\> \
        data_mem_Address\<3\> data_mem_Address\<2\> data_mem_Address\<1\> \
        data_mem_Address\<0\> data_mem_write_data_input\<31\> \
        data_mem_write_data_input\<30\> data_mem_write_data_input\<29\> \
        data_mem_write_data_input\<28\> data_mem_write_data_input\<27\> \
        data_mem_write_data_input\<26\> data_mem_write_data_input\<25\> \
        data_mem_write_data_input\<24\> data_mem_write_data_input\<23\> \
        data_mem_write_data_input\<22\> data_mem_write_data_input\<21\> \
        data_mem_write_data_input\<20\> data_mem_write_data_input\<19\> \
        data_mem_write_data_input\<18\> data_mem_write_data_input\<17\> \
        data_mem_write_data_input\<16\> data_mem_write_data_input\<15\> \
        data_mem_write_data_input\<14\> data_mem_write_data_input\<13\> \
        data_mem_write_data_input\<12\> data_mem_write_data_input\<11\> \
        data_mem_write_data_input\<10\> data_mem_write_data_input\<9\> \
        data_mem_write_data_input\<8\> data_mem_write_data_input\<7\> \
        data_mem_write_data_input\<6\> data_mem_write_data_input\<5\> \
        data_mem_write_data_input\<4\> data_mem_write_data_input\<3\> \
        data_mem_write_data_input\<2\> data_mem_write_data_input\<1\> \
        data_mem_write_data_input\<0\> data_mem_read_data\<31\> \
        data_mem_read_data\<30\> data_mem_read_data\<29\> \
        data_mem_read_data\<28\> data_mem_read_data\<27\> \
        data_mem_read_data\<26\> data_mem_read_data\<25\> \
        data_mem_read_data\<24\> data_mem_read_data\<23\> \
        data_mem_read_data\<22\> data_mem_read_data\<21\> \
        data_mem_read_data\<20\> data_mem_read_data\<19\> \
        data_mem_read_data\<18\> data_mem_read_data\<17\> \
        data_mem_read_data\<16\> data_mem_read_data\<15\> \
        data_mem_read_data\<14\> data_mem_read_data\<13\> \
        data_mem_read_data\<12\> data_mem_read_data\<11\> \
        data_mem_read_data\<10\> data_mem_read_data\<9\> \
        data_mem_read_data\<8\> data_mem_read_data\<7\> \
        data_mem_read_data\<6\> data_mem_read_data\<5\> \
        data_mem_read_data\<4\> data_mem_read_data\<3\> \
        data_mem_read_data\<2\> data_mem_read_data\<1\> \
        data_mem_read_data\<0\> NeTt_2363\<0\> NeTt_2363\<1\> n696 \
        data_mem_idle inh_gnd inh_gnds inh_vdd inh_vdds) \
        data_mem_wrap_address_width11
    time_module (d_clk_out timer\<63\> timer\<62\> timer\<61\> timer\<60\> \
        timer\<59\> timer\<58\> timer\<57\> timer\<56\> timer\<55\> \
        timer\<54\> timer\<53\> timer\<52\> timer\<51\> timer\<50\> \
        timer\<49\> timer\<48\> timer\<47\> timer\<46\> timer\<45\> \
        timer\<44\> timer\<43\> timer\<42\> timer\<41\> timer\<40\> \
        timer\<39\> timer\<38\> timer\<37\> timer\<36\> timer\<35\> \
        timer\<34\> timer\<33\> timer\<32\> timer\<31\> timer\<30\> \
        timer\<29\> timer\<28\> timer\<27\> timer\<26\> timer\<25\> \
        timer\<24\> timer\<23\> timer\<22\> timer\<21\> timer\<20\> \
        timer\<19\> timer\<18\> timer\<17\> timer\<16\> timer\<15\> \
        timer\<14\> timer\<13\> timer\<12\> timer\<11\> timer\<10\> \
        timer\<9\> timer\<8\> timer\<7\> timer\<6\> timer\<5\> timer\<4\> \
        timer\<3\> timer\<2\> timer\<1\> timer\<0\> n614 inh_gnd inh_gnds \
        inh_vdd inh_vdds) timer_schematic
    Thru0 (d_clk d_clk_out) iprobe
    sleep_controller (d_clk_out n614 cpu_spi_data_in\<31\> \
        cpu_spi_data_in\<30\> cpu_spi_data_in\<29\> cpu_spi_data_in\<28\> \
        cpu_spi_data_in\<27\> cpu_spi_data_in\<26\> cpu_spi_data_in\<25\> \
        cpu_spi_data_in\<24\> cpu_spi_data_in\<23\> cpu_spi_data_in\<22\> \
        cpu_spi_data_in\<21\> cpu_spi_data_in\<20\> cpu_spi_data_in\<19\> \
        cpu_spi_data_in\<18\> cpu_spi_data_in\<17\> cpu_spi_data_in\<16\> \
        cpu_spi_data_in\<15\> cpu_spi_data_in\<14\> cpu_spi_data_in\<13\> \
        cpu_spi_data_in\<12\> cpu_spi_data_in\<11\> cpu_spi_data_in\<10\> \
        cpu_spi_data_in\<9\> cpu_spi_data_in\<8\> cpu_spi_data_in\<7\> \
        cpu_spi_data_in\<6\> cpu_spi_data_in\<5\> cpu_spi_data_in\<4\> \
        cpu_spi_data_in\<3\> cpu_spi_data_in\<2\> cpu_spi_data_in\<1\> \
        cpu_spi_data_in\<0\> n658 sleep_we startup_spi_finished spi_busy \
        sleep_ctl inh_gnd inh_gnds inh_vdd inh_vdds) \
        sleep_controller_schematic
    spi_controller (d_clk_out n614 spi_settings data_to_spi\<31\> \
        data_to_spi\<30\> data_to_spi\<29\> data_to_spi\<28\> \
        data_to_spi\<27\> data_to_spi\<26\> data_to_spi\<25\> \
        data_to_spi\<24\> data_to_spi\<23\> data_to_spi\<22\> \
        data_to_spi\<21\> data_to_spi\<20\> data_to_spi\<19\> \
        data_to_spi\<18\> data_to_spi\<17\> data_to_spi\<16\> \
        data_to_spi\<15\> data_to_spi\<14\> data_to_spi\<13\> \
        data_to_spi\<12\> data_to_spi\<11\> data_to_spi\<10\> \
        data_to_spi\<9\> data_to_spi\<8\> data_to_spi\<7\> \
        data_to_spi\<6\> data_to_spi\<5\> data_to_spi\<4\> \
        data_to_spi\<3\> data_to_spi\<2\> data_to_spi\<1\> \
        data_to_spi\<0\> startup_spi_data_out\<31\> \
        startup_spi_data_out\<30\> startup_spi_data_out\<29\> \
        startup_spi_data_out\<28\> startup_spi_data_out\<27\> \
        startup_spi_data_out\<26\> startup_spi_data_out\<25\> \
        startup_spi_data_out\<24\> startup_spi_data_out\<23\> \
        startup_spi_data_out\<22\> startup_spi_data_out\<21\> \
        startup_spi_data_out\<20\> startup_spi_data_out\<19\> \
        startup_spi_data_out\<18\> startup_spi_data_out\<17\> \
        startup_spi_data_out\<16\> startup_spi_data_out\<15\> \
        startup_spi_data_out\<14\> startup_spi_data_out\<13\> \
        startup_spi_data_out\<12\> startup_spi_data_out\<11\> \
        startup_spi_data_out\<10\> startup_spi_data_out\<9\> \
        startup_spi_data_out\<8\> startup_spi_data_out\<7\> \
        startup_spi_data_out\<6\> startup_spi_data_out\<5\> \
        startup_spi_data_out\<4\> startup_spi_data_out\<3\> \
        startup_spi_data_out\<2\> startup_spi_data_out\<1\> \
        startup_spi_data_out\<0\> spi_busy startup_spi_finished spi_clear \
        spi_start miso mosi sclk cs1 cs2 cs3 cs4 inh_gnd inh_gnds inh_vdd \
        inh_vdds) soc_no_opt_16may_SPI_controller_schematic
    startup_controller (d_clk_out n614 skip_startup \
        SYNOPSYS_UNCONNECTED__0 SYNOPSYS_UNCONNECTED__1 \
        SYNOPSYS_UNCONNECTED__2 SYNOPSYS_UNCONNECTED__3 \
        SYNOPSYS_UNCONNECTED__4 startup_spi_data_in\<26\> \
        startup_spi_data_in\<25\> startup_spi_data_in\<24\> \
        SYNOPSYS_UNCONNECTED__5 SYNOPSYS_UNCONNECTED__6 \
        SYNOPSYS_UNCONNECTED__7 SYNOPSYS_UNCONNECTED__8 \
        SYNOPSYS_UNCONNECTED__9 SYNOPSYS_UNCONNECTED__10 \
        SYNOPSYS_UNCONNECTED__11 SYNOPSYS_UNCONNECTED__12 \
        SYNOPSYS_UNCONNECTED__13 SYNOPSYS_UNCONNECTED__14 \
        SYNOPSYS_UNCONNECTED__15 SYNOPSYS_UNCONNECTED__16 \
        SYNOPSYS_UNCONNECTED__17 SYNOPSYS_UNCONNECTED__18 \
        SYNOPSYS_UNCONNECTED__19 SYNOPSYS_UNCONNECTED__20 \
        SYNOPSYS_UNCONNECTED__21 SYNOPSYS_UNCONNECTED__22 \
        SYNOPSYS_UNCONNECTED__23 SYNOPSYS_UNCONNECTED__24 \
        SYNOPSYS_UNCONNECTED__25 SYNOPSYS_UNCONNECTED__26 \
        startup_spi_data_in\<1\> startup_spi_data_in\<0\> \
        startup_spi_data_out\<31\> startup_spi_data_out\<30\> \
        startup_spi_data_out\<29\> startup_spi_data_out\<28\> \
        startup_spi_data_out\<27\> startup_spi_data_out\<26\> \
        startup_spi_data_out\<25\> startup_spi_data_out\<24\> \
        startup_spi_data_out\<23\> startup_spi_data_out\<22\> \
        startup_spi_data_out\<21\> startup_spi_data_out\<20\> \
        startup_spi_data_out\<19\> startup_spi_data_out\<18\> \
        startup_spi_data_out\<17\> startup_spi_data_out\<16\> \
        startup_spi_data_out\<15\> startup_spi_data_out\<14\> \
        startup_spi_data_out\<13\> startup_spi_data_out\<12\> \
        startup_spi_data_out\<11\> startup_spi_data_out\<10\> \
        startup_spi_data_out\<9\> startup_spi_data_out\<8\> \
        startup_spi_data_out\<7\> startup_spi_data_out\<6\> \
        startup_spi_data_out\<5\> startup_spi_data_out\<4\> \
        startup_spi_data_out\<3\> startup_spi_data_out\<2\> \
        startup_spi_data_out\<1\> startup_spi_data_out\<0\> \
        startup_spi_finished startup_spi_start startup_spi_clear \
        startup_spi_settings startup_data_mem\<31\> startup_data_mem\<30\> \
        startup_data_mem\<29\> startup_data_mem\<28\> \
        startup_data_mem\<27\> startup_data_mem\<26\> \
        startup_data_mem\<25\> startup_data_mem\<24\> \
        startup_data_mem\<23\> startup_data_mem\<22\> \
        startup_data_mem\<21\> startup_data_mem\<20\> \
        startup_data_mem\<19\> startup_data_mem\<18\> \
        startup_data_mem\<17\> startup_data_mem\<16\> \
        startup_data_mem\<15\> startup_data_mem\<14\> \
        startup_data_mem\<13\> startup_data_mem\<12\> \
        startup_data_mem\<11\> startup_data_mem\<10\> \
        startup_data_mem\<9\> startup_data_mem\<8\> startup_data_mem\<7\> \
        startup_data_mem\<6\> startup_data_mem\<5\> startup_data_mem\<4\> \
        startup_data_mem\<3\> startup_data_mem\<2\> startup_data_mem\<1\> \
        startup_data_mem\<0\> startup_instr_addr\<10\> \
        startup_instr_addr\<9\> startup_instr_addr\<8\> \
        startup_instr_addr\<7\> startup_instr_addr\<6\> \
        startup_instr_addr\<5\> startup_instr_addr\<4\> \
        startup_instr_addr\<3\> startup_instr_addr\<2\> startup_data_we \
        startup_instr_we startup_done inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_spi_startup_schematic
    V3 (0 inh_gnd) vsource dc=0 type=dc
    V2 (inh_gnds inh_gnd) vsource dc=0 type=dc
    V1 (inh_vdds inh_gnd) vsource dc=-400m type=dc
    V0 (inh_vdd inh_gnd) vsource dc=350m type=dc
ends soc_top
// End of subcircuit definition.
