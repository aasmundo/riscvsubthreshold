// Generated for: spectre
// Generated on: May 16 13:11:49 2016
// Design library name: soc_no_opt_16may
// Design cell name: soc_top_inst
// Design view name: schematic
simulator lang=spectre
global 0 vdd gnds vdds VDD GND
//include "models.scs"
include "/home/aasmundo/newWorkdir/riscvsubthreshold/modules/1_corners.scs"

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_NADN2x1_PB4_AFBB
// View name: schematic
subckt LVT_NADN2x1_PB4_AFBB A B Z inh_gnd inh_gnds inh_vdd inh_vdds
    N1 (net10 A inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N0 (Z B net10 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f ad=39.2f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    P0 (Z A inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f ad=25.48f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    P1 (Z B inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f ad=25.48f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
ends LVT_NADN2x1_PB4_AFBB
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_invx2_PB4_AFBB
// View name: schematic
subckt LVT_invx2_PB4_AFBB in out inh_gnd inh_gnds inh_vdd inh_vdds
    N1 (out in inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f ad=28.0f \
        nf=(2)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 swrg=0 \
        swrsub=0 mismatch=1 m=1
    P1 (out in inh_vdd inh_vdds) lvtpfet w=550n l=30.00n as=53.9f ad=38.5f \
        nf=(2)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 swrg=0 \
        swrsub=0 mismatch=1 m=1
ends LVT_invx2_PB4_AFBB
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_RFDFFx1_PB4_AFBB
// View name: schematic
subckt LVT_RFDFFx1_PB4_AFBB CK D Q Qb inh_gnd inh_gnds inh_vdd inh_vdds
    N14 (Qb Q net059 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f ad=39.2f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    N13 (net059 net055 inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N12 (Q Qb net057 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f ad=39.2f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    N11 (net057 net051 inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N10 (net055 net015 net061 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N9 (net061 CK inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N3 (net069 net055 inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N1 (net070 net051 inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N2 (net09 D net069 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f ad=39.2f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    N0 (net039 net09 net070 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N6 (net015 net039 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    N7 (net051 net039 net063 inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N8 (net063 CK inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=39.2f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P14 (Qb net055 inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P13 (Qb Q inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P12 (Q Qb inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P11 (Q net051 inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P10 (net055 CK inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P9 (net055 net015 inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P1 (net039 net051 inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P0 (net039 net09 inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P2 (net09 net055 inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P3 (net09 D inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P6 (net015 net039 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    P7 (net051 CK inh_vdd inh_vdds) lvtpfet w=260n l=30n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P8 (net051 net039 inh_vdd inh_vdds) lvtpfet w=260n l=30.00n as=25.48f \
        ad=25.48f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
ends LVT_RFDFFx1_PB4_AFBB
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_invx1_PB4_AFBB
// View name: schematic
subckt LVT_invx1_PB4_AFBB in out inh_gnd inh_gnds inh_vdd inh_vdds
    N1 (out in inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f ad=19.6f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=106n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=1 swacc=0 swrg=0 \
        swrsub=0 mismatch=1 m=1
    P1 (out in inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=106n ptwell=0 par=1 \
        p_la=4n ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 \
        swacc=0 swrg=0 swrsub=0 mismatch=1 m=1
ends LVT_invx1_PB4_AFBB
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_NOR2x1_PB4_AFBB
// View name: schematic
subckt LVT_NOR2x1_PB4_AFBB A B Z inh_gnd inh_gnds inh_vdd inh_vdds
    N0 (Z A inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f ad=19.6f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    N1 (Z B inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f ad=19.6f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    P0 (net10 A inh_vdd inh_vdds) lvtpfet w=460n l=30.00n as=45.08f \
        ad=45.08f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P1 (Z B net10 inh_vdds) lvtpfet w=460n l=30.00n as=45.08f ad=45.08f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
ends LVT_NOR2x1_PB4_AFBB
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_BUFx1_PB4_AFBB
// View name: schematic
subckt LVT_BUFx1_PB4_AFBB in out inh_gnd inh_gnds inh_vdd inh_vdds
    N0 (out net8 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    N1 (net8 in inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    P0 (out net8 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    P1 (net8 in inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
ends LVT_BUFx1_PB4_AFBB
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: IDEX_preg
// View name: schematic
subckt soc_no_opt_16may_IDEX_preg_schematic clk flush \
        ALU_operation_in\<3\> ALU_operation_in\<2\> ALU_operation_in\<1\> \
        ALU_operation_in\<0\> ALU_operation_out\<3\> \
        ALU_operation_out\<2\> ALU_operation_out\<1\> \
        ALU_operation_out\<0\> reg1_out\<31\> reg1_out\<30\> \
        reg1_out\<29\> reg1_out\<28\> reg1_out\<27\> reg1_out\<26\> \
        reg1_out\<25\> reg1_out\<24\> reg1_out\<23\> reg1_out\<22\> \
        reg1_out\<21\> reg1_out\<20\> reg1_out\<19\> reg1_out\<18\> \
        reg1_out\<17\> reg1_out\<16\> reg1_out\<15\> reg1_out\<14\> \
        reg1_out\<13\> reg1_out\<12\> reg1_out\<11\> reg1_out\<10\> \
        reg1_out\<9\> reg1_out\<8\> reg1_out\<7\> reg1_out\<6\> \
        reg1_out\<5\> reg1_out\<4\> reg1_out\<3\> reg1_out\<2\> \
        reg1_out\<1\> reg1_out\<0\> reg2_out\<31\> reg2_out\<30\> \
        reg2_out\<29\> reg2_out\<28\> reg2_out\<27\> reg2_out\<26\> \
        reg2_out\<25\> reg2_out\<24\> reg2_out\<23\> reg2_out\<22\> \
        reg2_out\<21\> reg2_out\<20\> reg2_out\<19\> reg2_out\<18\> \
        reg2_out\<17\> reg2_out\<16\> reg2_out\<15\> reg2_out\<14\> \
        reg2_out\<13\> reg2_out\<12\> reg2_out\<11\> reg2_out\<10\> \
        reg2_out\<9\> reg2_out\<8\> reg2_out\<7\> reg2_out\<6\> \
        reg2_out\<5\> reg2_out\<4\> reg2_out\<3\> reg2_out\<2\> \
        reg2_out\<1\> reg2_out\<0\> imm_out\<31\> imm_out\<30\> \
        imm_out\<29\> imm_out\<28\> imm_out\<27\> imm_out\<26\> \
        imm_out\<25\> imm_out\<24\> imm_out\<23\> imm_out\<22\> \
        imm_out\<21\> imm_out\<20\> imm_out\<19\> imm_out\<18\> \
        imm_out\<17\> imm_out\<16\> imm_out\<15\> imm_out\<14\> \
        imm_out\<13\> imm_out\<12\> imm_out\<11\> imm_out\<10\> \
        imm_out\<9\> imm_out\<8\> imm_out\<7\> imm_out\<6\> imm_out\<5\> \
        imm_out\<4\> imm_out\<3\> imm_out\<2\> imm_out\<1\> imm_out\<0\> \
        is_imm_out rs1_out\<4\> rs1_out\<3\> rs1_out\<2\> rs1_out\<1\> \
        rs1_out\<0\> rs2_out\<4\> rs2_out\<3\> rs2_out\<2\> rs2_out\<1\> \
        rs2_out\<0\> rd_out\<4\> rd_out\<3\> rd_out\<2\> rd_out\<1\> \
        rd_out\<0\> reg1_in\<31\> reg1_in\<30\> reg1_in\<29\> \
        reg1_in\<28\> reg1_in\<27\> reg1_in\<26\> reg1_in\<25\> \
        reg1_in\<24\> reg1_in\<23\> reg1_in\<22\> reg1_in\<21\> \
        reg1_in\<20\> reg1_in\<19\> reg1_in\<18\> reg1_in\<17\> \
        reg1_in\<16\> reg1_in\<15\> reg1_in\<14\> reg1_in\<13\> \
        reg1_in\<12\> reg1_in\<11\> reg1_in\<10\> reg1_in\<9\> \
        reg1_in\<8\> reg1_in\<7\> reg1_in\<6\> reg1_in\<5\> reg1_in\<4\> \
        reg1_in\<3\> reg1_in\<2\> reg1_in\<1\> reg1_in\<0\> reg2_in\<31\> \
        reg2_in\<30\> reg2_in\<29\> reg2_in\<28\> reg2_in\<27\> \
        reg2_in\<26\> reg2_in\<25\> reg2_in\<24\> reg2_in\<23\> \
        reg2_in\<22\> reg2_in\<21\> reg2_in\<20\> reg2_in\<19\> \
        reg2_in\<18\> reg2_in\<17\> reg2_in\<16\> reg2_in\<15\> \
        reg2_in\<14\> reg2_in\<13\> reg2_in\<12\> reg2_in\<11\> \
        reg2_in\<10\> reg2_in\<9\> reg2_in\<8\> reg2_in\<7\> reg2_in\<6\> \
        reg2_in\<5\> reg2_in\<4\> reg2_in\<3\> reg2_in\<2\> reg2_in\<1\> \
        reg2_in\<0\> imm_in\<31\> imm_in\<30\> imm_in\<29\> imm_in\<28\> \
        imm_in\<27\> imm_in\<26\> imm_in\<25\> imm_in\<24\> imm_in\<23\> \
        imm_in\<22\> imm_in\<21\> imm_in\<20\> imm_in\<19\> imm_in\<18\> \
        imm_in\<17\> imm_in\<16\> imm_in\<15\> imm_in\<14\> imm_in\<13\> \
        imm_in\<12\> imm_in\<11\> imm_in\<10\> imm_in\<9\> imm_in\<8\> \
        imm_in\<7\> imm_in\<6\> imm_in\<5\> imm_in\<4\> imm_in\<3\> \
        imm_in\<2\> imm_in\<1\> imm_in\<0\> is_imm_in rs1_in\<4\> \
        rs1_in\<3\> rs1_in\<2\> rs1_in\<1\> rs1_in\<0\> rs2_in\<4\> \
        rs2_in\<3\> rs2_in\<2\> rs2_in\<1\> rs2_in\<0\> rd_in\<4\> \
        rd_in\<3\> rd_in\<2\> rd_in\<1\> rd_in\<0\> mem_we_in mem_re_in \
        mem_be_in\<1\> mem_be_in\<0\> mem_load_unsigned_in \
        mem_load_unsigned_out wb_src_in\<1\> wb_src_in\<0\> wb_we_in \
        mem_we_out mem_re_out mem_be_out\<1\> mem_be_out\<0\> \
        wb_src_out\<1\> wb_src_out\<0\> wb_we_out is_branch_in \
        is_branch_out branch_target_in\<10\> branch_target_in\<9\> \
        branch_target_in\<8\> branch_target_in\<7\> branch_target_in\<6\> \
        branch_target_in\<5\> branch_target_in\<4\> branch_target_in\<3\> \
        branch_target_in\<2\> branch_target_in\<1\> branch_target_in\<0\> \
        branch_target_out\<10\> branch_target_out\<9\> \
        branch_target_out\<8\> branch_target_out\<7\> \
        branch_target_out\<6\> branch_target_out\<5\> \
        branch_target_out\<4\> branch_target_out\<3\> \
        branch_target_out\<2\> branch_target_out\<1\> \
        branch_target_out\<0\> current_PC_in\<10\> current_PC_in\<9\> \
        current_PC_in\<8\> current_PC_in\<7\> current_PC_in\<6\> \
        current_PC_in\<5\> current_PC_in\<4\> current_PC_in\<3\> \
        current_PC_in\<2\> current_PC_in\<1\> current_PC_in\<0\> \
        current_PC_out\<10\> current_PC_out\<9\> current_PC_out\<8\> \
        current_PC_out\<7\> current_PC_out\<6\> current_PC_out\<5\> \
        current_PC_out\<4\> current_PC_out\<3\> current_PC_out\<2\> \
        current_PC_out\<1\> current_PC_out\<0\> reg_or_PC_in reg_or_PC_out \
        is_jump_in is_jump_out PC_incr_in\<10\> PC_incr_in\<9\> \
        PC_incr_in\<8\> PC_incr_in\<7\> PC_incr_in\<6\> PC_incr_in\<5\> \
        PC_incr_in\<4\> PC_incr_in\<3\> PC_incr_in\<2\> PC_incr_in\<1\> \
        PC_incr_in\<0\> PC_incr_out\<10\> PC_incr_out\<9\> \
        PC_incr_out\<8\> PC_incr_out\<7\> PC_incr_out\<6\> \
        PC_incr_out\<5\> PC_incr_out\<4\> PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> branched_in \
        branched_out inh_gnd inh_gnds inh_vdd inh_vdds
    wb_src_out_reg_1_ (clk wb_src_in\<1\> NeTt_727 n133 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_src_out_reg_0_ (clk wb_src_in\<0\> NeTt_728 n135 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_be_out_reg_1_ (clk n110 mem_be_out\<1\> NeTt_729 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_be_out_reg_0_ (clk n97 mem_be_out\<0\> NeTt_730 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_we_out_reg (clk N10 wb_we_out NeTt_731 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    is_branch_out_reg (clk n144 is_branch_out NeTt_732 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    is_jump_out_reg (clk n145 is_jump_out NeTt_733 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branched_out_reg (clk n146 branched_out NeTt_734 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_we_out_reg (clk n152 mem_we_out NeTt_735 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_re_out_reg (clk n153 mem_re_out NeTt_736 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_out_reg_1_ (clk n119 NeTt_737 n102 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_out_reg_3_ (clk n111 NeTt_738 n99 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_4_ (clk n151 NeTt_739 n130 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_2_ (clk n149 NeTt_740 n128 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_3_ (clk n150 NeTt_741 n122 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_0_ (clk n147 NeTt_742 n124 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_1_ (clk n148 NeTt_743 n114 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    is_imm_out_reg (clk is_imm_in NeTt_744 n132 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_load_unsigned_out_reg (clk n98 mem_load_unsigned_out NeTt_745 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_out_reg_0_ (clk rs2_in\<0\> NeTt_746 n141 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_out_reg_2_ (clk rs2_in\<2\> NeTt_747 n116 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_out_reg_4_ (clk rs2_in\<4\> NeTt_748 n108 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_operation_out_reg_1_ (clk ALU_operation_in\<1\> NeTt_749 n139 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_operation_out_reg_0_ (clk ALU_operation_in\<0\> NeTt_750 n126 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_operation_out_reg_2_ (clk ALU_operation_in\<2\> NeTt_751 n104 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs1_out_reg_0_ (clk rs1_in\<0\> NeTt_752 n137 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs1_out_reg_3_ (clk rs1_in\<3\> NeTt_753 n120 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs1_out_reg_1_ (clk n118 rs1_out\<1\> NeTt_754 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs1_out_reg_2_ (clk rs1_in\<2\> NeTt_755 n112 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs1_out_reg_4_ (clk rs1_in\<4\> NeTt_756 n106 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg_or_PC_out_reg (clk reg_or_PC_in reg_or_PC_out NeTt_757 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_0_ (clk imm_in\<0\> imm_out\<0\> NeTt_758 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_1_ (clk imm_in\<1\> imm_out\<1\> NeTt_759 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_2_ (clk imm_in\<2\> imm_out\<2\> NeTt_760 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_3_ (clk imm_in\<3\> imm_out\<3\> NeTt_761 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_4_ (clk imm_in\<4\> imm_out\<4\> NeTt_762 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_5_ (clk imm_in\<5\> imm_out\<5\> NeTt_763 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_6_ (clk imm_in\<6\> imm_out\<6\> NeTt_764 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_7_ (clk imm_in\<7\> imm_out\<7\> NeTt_765 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_8_ (clk imm_in\<8\> imm_out\<8\> NeTt_766 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_9_ (clk imm_in\<9\> imm_out\<9\> NeTt_767 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_10_ (clk imm_in\<10\> imm_out\<10\> NeTt_768 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_11_ (clk imm_in\<11\> imm_out\<11\> NeTt_769 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_12_ (clk imm_in\<12\> imm_out\<12\> NeTt_770 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_13_ (clk imm_in\<13\> imm_out\<13\> NeTt_771 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_14_ (clk imm_in\<14\> imm_out\<14\> NeTt_772 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_15_ (clk imm_in\<15\> imm_out\<15\> NeTt_773 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_16_ (clk imm_in\<16\> imm_out\<16\> NeTt_774 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_17_ (clk imm_in\<17\> imm_out\<17\> NeTt_775 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_18_ (clk imm_in\<18\> imm_out\<18\> NeTt_776 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_19_ (clk imm_in\<19\> imm_out\<19\> NeTt_777 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_20_ (clk imm_in\<20\> imm_out\<20\> NeTt_778 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_21_ (clk imm_in\<21\> imm_out\<21\> NeTt_779 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_22_ (clk imm_in\<22\> imm_out\<22\> NeTt_780 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_23_ (clk imm_in\<23\> imm_out\<23\> NeTt_781 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_24_ (clk imm_in\<24\> imm_out\<24\> NeTt_782 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_25_ (clk imm_in\<25\> imm_out\<25\> NeTt_783 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_26_ (clk imm_in\<26\> imm_out\<26\> NeTt_784 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_27_ (clk imm_in\<27\> imm_out\<27\> NeTt_785 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_28_ (clk imm_in\<28\> imm_out\<28\> NeTt_786 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_29_ (clk imm_in\<29\> imm_out\<29\> NeTt_787 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_30_ (clk imm_in\<30\> imm_out\<30\> NeTt_788 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    imm_out_reg_31_ (clk imm_in\<31\> imm_out\<31\> NeTt_789 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_0_ (clk reg2_in\<0\> reg2_out\<0\> NeTt_790 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_1_ (clk reg2_in\<1\> reg2_out\<1\> NeTt_791 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_2_ (clk reg2_in\<2\> reg2_out\<2\> NeTt_792 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_3_ (clk reg2_in\<3\> reg2_out\<3\> NeTt_793 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_4_ (clk reg2_in\<4\> reg2_out\<4\> NeTt_794 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_5_ (clk reg2_in\<5\> reg2_out\<5\> NeTt_795 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_6_ (clk reg2_in\<6\> reg2_out\<6\> NeTt_796 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_7_ (clk reg2_in\<7\> reg2_out\<7\> NeTt_797 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_8_ (clk reg2_in\<8\> reg2_out\<8\> NeTt_798 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_9_ (clk reg2_in\<9\> reg2_out\<9\> NeTt_799 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_10_ (clk reg2_in\<10\> reg2_out\<10\> NeTt_800 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_11_ (clk reg2_in\<11\> reg2_out\<11\> NeTt_801 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_12_ (clk reg2_in\<12\> reg2_out\<12\> NeTt_802 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_13_ (clk reg2_in\<13\> reg2_out\<13\> NeTt_803 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_14_ (clk reg2_in\<14\> reg2_out\<14\> NeTt_804 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_15_ (clk reg2_in\<15\> reg2_out\<15\> NeTt_805 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_16_ (clk reg2_in\<16\> reg2_out\<16\> NeTt_806 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_17_ (clk reg2_in\<17\> reg2_out\<17\> NeTt_807 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_18_ (clk reg2_in\<18\> reg2_out\<18\> NeTt_808 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_19_ (clk reg2_in\<19\> reg2_out\<19\> NeTt_809 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_20_ (clk reg2_in\<20\> reg2_out\<20\> NeTt_810 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_21_ (clk reg2_in\<21\> reg2_out\<21\> NeTt_811 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_22_ (clk reg2_in\<22\> reg2_out\<22\> NeTt_812 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_23_ (clk reg2_in\<23\> reg2_out\<23\> NeTt_813 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_24_ (clk reg2_in\<24\> reg2_out\<24\> NeTt_814 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_25_ (clk reg2_in\<25\> reg2_out\<25\> NeTt_815 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_26_ (clk reg2_in\<26\> reg2_out\<26\> NeTt_816 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_27_ (clk reg2_in\<27\> reg2_out\<27\> NeTt_817 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_28_ (clk reg2_in\<28\> reg2_out\<28\> NeTt_818 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_29_ (clk reg2_in\<29\> reg2_out\<29\> NeTt_819 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_30_ (clk reg2_in\<30\> reg2_out\<30\> NeTt_820 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg2_out_reg_31_ (clk reg2_in\<31\> reg2_out\<31\> NeTt_821 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_0_ (clk reg1_in\<0\> reg1_out\<0\> NeTt_822 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_1_ (clk reg1_in\<1\> reg1_out\<1\> NeTt_823 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_2_ (clk reg1_in\<2\> reg1_out\<2\> NeTt_824 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_3_ (clk reg1_in\<3\> reg1_out\<3\> NeTt_825 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_4_ (clk reg1_in\<4\> reg1_out\<4\> NeTt_826 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_5_ (clk reg1_in\<5\> reg1_out\<5\> NeTt_827 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_6_ (clk reg1_in\<6\> reg1_out\<6\> NeTt_828 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_7_ (clk reg1_in\<7\> reg1_out\<7\> NeTt_829 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_8_ (clk reg1_in\<8\> reg1_out\<8\> NeTt_830 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_9_ (clk reg1_in\<9\> reg1_out\<9\> NeTt_831 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_10_ (clk reg1_in\<10\> reg1_out\<10\> NeTt_832 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_11_ (clk reg1_in\<11\> reg1_out\<11\> NeTt_833 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_12_ (clk reg1_in\<12\> reg1_out\<12\> NeTt_834 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_13_ (clk reg1_in\<13\> reg1_out\<13\> NeTt_835 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_14_ (clk reg1_in\<14\> reg1_out\<14\> NeTt_836 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_15_ (clk reg1_in\<15\> reg1_out\<15\> NeTt_837 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_16_ (clk reg1_in\<16\> reg1_out\<16\> NeTt_838 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_17_ (clk reg1_in\<17\> reg1_out\<17\> NeTt_839 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_18_ (clk reg1_in\<18\> reg1_out\<18\> NeTt_840 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_19_ (clk reg1_in\<19\> reg1_out\<19\> NeTt_841 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_20_ (clk reg1_in\<20\> reg1_out\<20\> NeTt_842 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_21_ (clk reg1_in\<21\> reg1_out\<21\> NeTt_843 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_22_ (clk reg1_in\<22\> reg1_out\<22\> NeTt_844 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_23_ (clk reg1_in\<23\> reg1_out\<23\> NeTt_845 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_24_ (clk reg1_in\<24\> reg1_out\<24\> NeTt_846 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_25_ (clk reg1_in\<25\> reg1_out\<25\> NeTt_847 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_26_ (clk reg1_in\<26\> reg1_out\<26\> NeTt_848 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_27_ (clk reg1_in\<27\> reg1_out\<27\> NeTt_849 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_28_ (clk reg1_in\<28\> reg1_out\<28\> NeTt_850 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_29_ (clk reg1_in\<29\> reg1_out\<29\> NeTt_851 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_30_ (clk reg1_in\<30\> reg1_out\<30\> NeTt_852 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    reg1_out_reg_31_ (clk reg1_in\<31\> reg1_out\<31\> NeTt_853 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_operation_out_reg_3_ (clk ALU_operation_in\<3\> \
        ALU_operation_out\<3\> NeTt_854 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_0_ (clk PC_incr_in\<0\> PC_incr_out\<0\> NeTt_855 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_1_ (clk PC_incr_in\<1\> PC_incr_out\<1\> NeTt_856 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_2_ (clk PC_incr_in\<2\> PC_incr_out\<2\> NeTt_857 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_3_ (clk PC_incr_in\<3\> PC_incr_out\<3\> NeTt_858 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_4_ (clk PC_incr_in\<4\> PC_incr_out\<4\> NeTt_859 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_5_ (clk PC_incr_in\<5\> PC_incr_out\<5\> NeTt_860 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_6_ (clk PC_incr_in\<6\> PC_incr_out\<6\> NeTt_861 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_7_ (clk PC_incr_in\<7\> PC_incr_out\<7\> NeTt_862 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_8_ (clk PC_incr_in\<8\> PC_incr_out\<8\> NeTt_863 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_9_ (clk PC_incr_in\<9\> PC_incr_out\<9\> NeTt_864 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_10_ (clk PC_incr_in\<10\> PC_incr_out\<10\> NeTt_865 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_0_ (clk current_PC_in\<0\> current_PC_out\<0\> \
        NeTt_866 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_1_ (clk current_PC_in\<1\> current_PC_out\<1\> \
        NeTt_867 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_2_ (clk current_PC_in\<2\> current_PC_out\<2\> \
        NeTt_868 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_3_ (clk current_PC_in\<3\> current_PC_out\<3\> \
        NeTt_869 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_4_ (clk current_PC_in\<4\> current_PC_out\<4\> \
        NeTt_870 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_5_ (clk current_PC_in\<5\> current_PC_out\<5\> \
        NeTt_871 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_6_ (clk current_PC_in\<6\> current_PC_out\<6\> \
        NeTt_872 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_7_ (clk current_PC_in\<7\> current_PC_out\<7\> \
        NeTt_873 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_8_ (clk current_PC_in\<8\> current_PC_out\<8\> \
        NeTt_874 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_9_ (clk current_PC_in\<9\> current_PC_out\<9\> \
        NeTt_875 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    current_PC_out_reg_10_ (clk current_PC_in\<10\> current_PC_out\<10\> \
        NeTt_876 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_0_ (clk branch_target_in\<0\> \
        branch_target_out\<0\> NeTt_877 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_1_ (clk branch_target_in\<1\> \
        branch_target_out\<1\> NeTt_878 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_2_ (clk branch_target_in\<2\> \
        branch_target_out\<2\> NeTt_879 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_3_ (clk branch_target_in\<3\> \
        branch_target_out\<3\> NeTt_880 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_4_ (clk branch_target_in\<4\> \
        branch_target_out\<4\> NeTt_881 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_5_ (clk branch_target_in\<5\> \
        branch_target_out\<5\> NeTt_882 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_6_ (clk branch_target_in\<6\> \
        branch_target_out\<6\> NeTt_883 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_7_ (clk branch_target_in\<7\> \
        branch_target_out\<7\> NeTt_884 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_8_ (clk branch_target_in\<8\> \
        branch_target_out\<8\> NeTt_885 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_9_ (clk branch_target_in\<9\> \
        branch_target_out\<9\> NeTt_886 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_10_ (clk branch_target_in\<10\> \
        branch_target_out\<10\> NeTt_887 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U46 (n135 wb_src_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U45 (n133 wb_src_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U52 (wb_we_in n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n102 rs2_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n99 rs2_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U43 (n130 rd_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U41 (n128 rd_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U33 (n122 rd_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U38 (n124 rd_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (n114 rd_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U50 (n132 is_imm_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n141 rs2_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (n116 rs2_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U10 (n108 rs2_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U48 (n139 ALU_operation_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U40 (n126 ALU_operation_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (n104 ALU_operation_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U47 (n137 rs1_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (n120 rs1_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n112 rs1_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n106 rs1_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U51 (flush n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (flush n101 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (mem_be_in\<1\> n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U3 (mem_be_in\<0\> n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U28 (rs2_in\<1\> n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U12 (rs2_in\<3\> n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U4 (mem_load_unsigned_in n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U27 (rs1_in\<1\> n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U37 (n22 n144 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U31 (n21 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U29 (n20 n146 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U35 (n14 n152 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U36 (n13 n153 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U44 (n15 n151 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U42 (n17 n149 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U34 (n16 n150 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U39 (n19 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U30 (n18 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U24 (is_branch_in n101 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (is_jump_in n154 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (branched_in n101 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (mem_we_in n101 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U15 (mem_re_in n101 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (n154 rd_in\<4\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (n101 rd_in\<2\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (n101 rd_in\<3\> n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U21 (n154 rd_in\<0\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (n154 rd_in\<1\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n155 flush N10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_IDEX_preg_schematic
// End of subcircuit definition.

// Library name: S28_coreLVTPB4_AFBB
// Cell name: LVT_FAx1_PB4_AFBB
// View name: schematic
subckt LVT_FAx1_PB4_AFBB A B Cin Cout sum inh_gnd inh_gnds inh_vdd \
        inh_vdds
    N16 (net047 net04 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N15 (net028 net08 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N14 (net028 net04 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N13 (sum net08 net047 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N12 (sum Cout net028 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N11 (Cout net012 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    N10 (net051 A inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N9 (net011 B inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N8 (net011 A inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N7 (net012 B net051 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N6 (net012 Cin net011 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N4 (net08 B net016 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f ad=19.6f \
        nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n ngcon=1 \
        nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 swrg=-1 \
        swrsub=-1 mismatch=1 m=1
    N2 (net08 Cin net07 inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N3 (net016 net04 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N1 (net07 B inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N0 (net07 net04 inh_gnd inh_gnds) lvtnfet w=200n l=30.00n as=19.6f \
        ad=19.6f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    N5 (net04 A inh_gnd inh_gnds) lvtnfet w=400n l=30.00n as=39.2f \
        ad=28.0f nf=(2)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    P16 (net030 net04 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P15 (net030 net08 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P14 (net048 net04 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P13 (sum net08 net048 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P12 (sum Cout net030 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P11 (Cout net012 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
    P10 (net052 A inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P9 (net013 B inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P8 (net013 A inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P7 (net012 B net052 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P6 (net012 Cin net013 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P3 (net017 net04 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P1 (net09 B inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P0 (net09 net04 inh_vdd inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P4 (net08 B net017 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P2 (net08 Cin net09 inh_vdds) lvtpfet w=275n l=30.00n as=26.95f \
        ad=26.95f nf=(1)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=-1 \
        swrg=-1 swrsub=-1 mismatch=1 m=1
    P5 (net04 A inh_vdd inh_vdds) lvtpfet w=550n l=30.00n as=53.9f \
        ad=38.5f nf=(2)*(1) sa=1.8u sb=1.8u sd=96n ptwell=0 par=1 p_la=4n \
        ngcon=1 nsig_delvto_uo1=0 nsig_delvto_uo2=0 soa=1 swshe=0 swacc=0 \
        swrg=0 swrsub=0 mismatch=1 m=1
ends LVT_FAx1_PB4_AFBB
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: branch_target_adder_DW01_add_0
// View name: schematic
subckt soc_no_opt_16may_branch_target_adder_DW01_add_0_schematic A\<10\> \
        A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> A\<3\> A\<2\> A\<1\> \
        A\<0\> B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> \
        B\<2\> B\<1\> B\<0\> CI SUM\<10\> SUM\<9\> SUM\<8\> SUM\<7\> \
        SUM\<6\> SUM\<5\> SUM\<4\> SUM\<3\> SUM\<2\> SUM\<1\> SUM\<0\> CO \
        inh_gnd inh_gnds inh_vdd inh_vdds
    U29 (n27 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (n28 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (carry\<4\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U22 (n21 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (carry\<6\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n19 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (carry\<8\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U18 (n17 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (carry\<7\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U16 (n15 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (carry\<9\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (n13 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (B\<1\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (A\<1\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (A\<1\> n24 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U28 (B\<1\> n23 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U23 (n24 n23 carry\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U5 (n36 SUM\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U10 (carry\<3\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U8 (n35 SUM\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U7 (n33 SUM\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U4 (n31 SUM\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U3 (n32 SUM\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U1 (n30 SUM\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U12 (carry\<5\> n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U6 (n34 SUM\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U11 (carry\<10\> n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U2 (n29 SUM\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (n37 SUM\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U1_3 (A\<3\> B\<3\> n10 carry\<4\> n36 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_4 (B\<4\> n22 A\<4\> carry\<5\> n35 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_6 (A\<6\> n20 B\<6\> carry\<7\> n33 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_8 (B\<8\> n18 A\<8\> carry\<9\> n31 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_7 (B\<7\> n16 A\<7\> carry\<8\> n32 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_9 (A\<9\> n14 B\<9\> carry\<10\> n30 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_5 (A\<5\> B\<5\> n12 carry\<6\> n34 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_10 (A\<10\> B\<10\> n11 NeTt_142 n29 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_2 (A\<2\> B\<2\> carry\<2\> carry\<3\> n37 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    Thru1 (A\<0\> A\[0\]) iprobe
    Thru0 (A\[0\] SUM\<0\>) iprobe
    U26 (n25 n26 SUM\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends soc_no_opt_16may_branch_target_adder_DW01_add_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: branch_target_adder
// View name: schematic
subckt soc_no_opt_16may_branch_target_adder_schematic PC_i\<10\> PC_i\<9\> \
        PC_i\<8\> PC_i\<7\> PC_i\<6\> PC_i\<5\> PC_i\<4\> PC_i\<3\> \
        PC_i\<2\> PC_i\<1\> PC_i\<0\> imm\<19\> imm\<18\> imm\<17\> \
        imm\<16\> imm\<15\> imm\<14\> imm\<13\> imm\<12\> imm\<11\> \
        imm\<10\> imm\<9\> imm\<8\> imm\<7\> imm\<6\> imm\<5\> imm\<4\> \
        imm\<3\> imm\<2\> imm\<1\> imm\<0\> PC_o\<10\> PC_o\<9\> PC_o\<8\> \
        PC_o\<7\> PC_o\<6\> PC_o\<5\> PC_o\<4\> PC_o\<3\> PC_o\<2\> \
        PC_o\<1\> PC_o\<0\> inh_gnd inh_gnds inh_vdd inh_vdds
    add_24 (PC_i\<10\> PC_i\<9\> n4 n5 PC_i\<6\> PC_i\<5\> n3 PC_i\<3\> \
        PC_i\<2\> PC_i\<1\> PC_i\<0\> imm\<9\> imm\<8\> imm\<7\> imm\<6\> \
        imm\<5\> imm\<4\> imm\<3\> imm\<2\> imm\<1\> imm\<0\> GND! GND! \
        PC_o\<10\> PC_o\<9\> PC_o\<8\> PC_o\<7\> PC_o\<6\> PC_o\<5\> \
        PC_o\<4\> PC_o\<3\> PC_o\<2\> PC_o\<1\> PC_o\<0\> NeTt_21 inh_gnd \
        inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_branch_target_adder_DW01_add_0_schematic
    U9 (n7 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (PC_i\<7\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n6 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (PC_i\<8\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n8 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (PC_i\<4\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
ends soc_no_opt_16may_branch_target_adder_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: PC_increment
// View name: schematic
subckt soc_no_opt_16may_PC_increment_schematic input0\<10\> input0\<9\> \
        input0\<8\> input0\<7\> input0\<6\> input0\<5\> input0\<4\> \
        input0\<3\> input0\<2\> input0\<1\> input0\<0\> output0\<10\> \
        output0\<9\> output0\<8\> output0\<7\> output0\<6\> output0\<5\> \
        output0\<4\> output0\<3\> output0\<2\> output0\<1\> output0\<0\> \
        inh_gnd inh_gnds inh_vdd inh_vdds
    U3 (n6 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (add_21\#2fcarry\[10\] n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U18 (input0\<2\> output0\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (input0\<3\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (input0\<4\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U10 (add_21\#2fcarry\[4\] n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U16 (input0\<5\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (add_21\#2fcarry\[5\] n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (input0\<6\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (add_21\#2fcarry\[6\] n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (input0\<8\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (input0\<9\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U11 (input0\<7\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (add_21\#2fcarry\[7\] n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (add_21\#2fcarry\[8\] n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (add_21\#2fcarry\[9\] n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (input0\<10\> n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U22 (n1 n7 add_21\#2fcarry\[10\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U46 (output0\<2\> n30 add_21\#2fcarry\[4\] inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U42 (n27 n26 add_21\#2fcarry\[5\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U38 (n22 n23 add_21\#2fcarry\[6\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U34 (n19 n18 add_21\#2fcarry\[7\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U30 (n14 n15 add_21\#2fcarry\[8\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U26 (n10 n11 add_21\#2fcarry\[9\] inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    Thru3 (input0\<0\> input0\[0\]) iprobe
    Thru2 (input0\[0\] output0\<0\>) iprobe
    Thru1 (input0\<1\> input0\[1\]) iprobe
    Thru0 (input0\[1\] output0\<1\>) iprobe
    U49 (n30 input0\<2\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n31 n32 output0\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (input0\<3\> output0\<2\> n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n26 add_21\#2fcarry\[4\] n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n29 n28 output0\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n27 input0\<4\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n22 add_21\#2fcarry\[5\] n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (n25 n24 output0\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n23 input0\<5\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n18 add_21\#2fcarry\[6\] n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n21 n20 output0\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n19 input0\<6\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n14 add_21\#2fcarry\[7\] n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n17 n16 output0\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (n15 input0\<7\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n10 add_21\#2fcarry\[8\] n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n13 n12 output0\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n11 input0\<8\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n1 add_21\#2fcarry\[9\] n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (n8 n9 output0\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (n7 input0\<9\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (n3 n4 output0\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (n5 input0\<10\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends soc_no_opt_16may_PC_increment_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: PC
// View name: schematic
subckt soc_no_opt_16may_PC_schematic clk we nreset PC_out\<10\> \
        PC_out\<9\> PC_out\<8\> PC_out\<7\> PC_out\<6\> PC_out\<5\> \
        PC_out\<4\> PC_out\<3\> PC_out\<2\> PC_out\<1\> PC_out\<0\> \
        PC_next\<10\> PC_next\<9\> PC_next\<8\> PC_next\<7\> PC_next\<6\> \
        PC_next\<5\> PC_next\<4\> PC_next\<3\> PC_next\<2\> PC_next\<1\> \
        PC_next\<0\> PC_in\<10\> PC_in\<9\> PC_in\<8\> PC_in\<7\> \
        PC_in\<6\> PC_in\<5\> PC_in\<4\> PC_in\<3\> PC_in\<2\> PC_in\<1\> \
        PC_in\<0\> inh_gnd inh_gnds inh_vdd inh_vdds
    U96 (PC_in\<9\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U84 (n65 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U94 (n70 PC_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U93 (n69 PC_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U92 (n73 PC_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U90 (n74 n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U89 (n72 PC_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U87 (n4 n85 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n64 PC_out\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U83 (n63 PC_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U81 (n66 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U79 (n71 n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U97 (n29 n95 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U91 (n68 PC_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U76 (n88 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U88 (n1 PC_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n85 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U85 (n2 PC_out\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n82 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (n3 PC_out\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n79 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U80 (n67 PC_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (n77 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n93 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U78 (n26 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U95 (we n93 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n94 nreset n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n25 n26 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n82 n76 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n23 n24 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U12 (n76 PC_out\<1\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (PC_in\<1\> n95 n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (n7 n8 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U9 (PC_out\<0\> n76 n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U8 (PC_in\<0\> n95 n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U7 (n5 n6 n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NADN2x1_PB4_AFBB
    U21 (PC_out\<4\> n76 n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (PC_in\<4\> n95 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U19 (n13 n14 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (n88 n76 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (PC_in\<5\> n95 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n15 n16 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U18 (PC_out\<3\> n76 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U17 (PC_in\<3\> n95 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U16 (n11 n12 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (n85 n76 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (PC_in\<6\> n95 n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n17 n18 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (PC_out\<8\> n76 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (PC_in\<8\> n95 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n21 n22 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (PC_out\<7\> n76 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (PC_in\<7\> n95 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n19 n20 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n79 n76 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (PC_in\<10\> n95 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n27 n28 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U14 (PC_in\<2\> n95 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U15 (n77 n76 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U13 (n9 n10 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (PC_out\<0\> n93 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n50 n51 PC_next\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n75 PC_in\<0\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n88 n93 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n38 n39 PC_next\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (we PC_in\<5\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n85 n93 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n36 n37 PC_next\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (PC_in\<6\> we n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n82 n93 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n30 n31 PC_next\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (we PC_in\<9\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n79 n93 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n48 n49 PC_next\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (we PC_in\<10\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n77 n93 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n44 n45 PC_next\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n75 PC_in\<2\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (PC_out\<1\> n93 n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n46 n47 PC_next\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (PC_in\<1\> n75 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (PC_out\<3\> n93 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n42 n43 PC_next\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (we PC_in\<3\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (PC_in\<8\> we n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n32 n33 PC_next\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (PC_out\<8\> n93 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (PC_out\<4\> n93 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n40 n41 PC_next\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n75 PC_in\<4\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (PC_out\<7\> n93 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n34 n35 PC_next\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n75 PC_in\<7\> n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (nreset n26 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (nreset n93 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    PC_reg_9_ (clk n61 NeTt_264 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_1_ (clk n53 NeTt_265 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_0_ (clk n52 NeTt_266 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_4_ (clk n56 NeTt_267 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_5_ (clk n57 NeTt_268 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_3_ (clk n55 NeTt_269 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_6_ (clk n58 NeTt_270 n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_8_ (clk n60 NeTt_271 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_7_ (clk n59 NeTt_272 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_10_ (clk n62 NeTt_273 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    PC_reg_2_ (clk n54 NeTt_274 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
ends soc_no_opt_16may_PC_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: branch_predictor_prediction_window5
// View name: schematic
subckt branch_predictor_prediction_window5_schematic clk nreset \
        PC_incr_IF\<4\> PC_incr_IF\<3\> PC_incr_IF\<2\> PC_incr_IF\<1\> \
        PC_incr_IF\<0\> PC_incr_MEM\<4\> PC_incr_MEM\<3\> PC_incr_MEM\<2\> \
        PC_incr_MEM\<1\> PC_incr_MEM\<0\> prediction branch_MEM \
        is_branch_MEM inh_gnd inh_gnds inh_vdd inh_vdds
    prediction_table_reg_9__0_ (clk n321 NeTt_2027 n399 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_9__1_ (clk n322 NeTt_2028 n757 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_8__0_ (clk n323 NeTt_2029 n397 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_8__1_ (clk n324 NeTt_2030 n758 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_7__0_ (clk n325 NeTt_2031 n395 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_7__1_ (clk n326 NeTt_2032 n759 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_5__0_ (clk n329 NeTt_2033 n393 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_0__1_ (clk n340 NeTt_2034 n766 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_0__0_ (clk n339 NeTt_2035 n385 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_31__1_ (clk n278 NeTt_2036 n735 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_31__0_ (clk n277 NeTt_2037 n378 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_16__1_ (clk n308 NeTt_2038 n750 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_16__0_ (clk n307 NeTt_2039 n346 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_15__1_ (clk n310 NeTt_2040 n751 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_15__0_ (clk n309 NeTt_2041 n407 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_23__1_ (clk n294 NeTt_2042 n743 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_23__0_ (clk n293 NeTt_2043 n368 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_24__1_ (clk n292 NeTt_2044 n742 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_24__0_ (clk n291 NeTt_2045 n354 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_30__1_ (clk n280 NeTt_2046 n736 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_30__0_ (clk n279 NeTt_2047 n358 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_1__1_ (clk n338 NeTt_2048 n765 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_1__0_ (clk n337 NeTt_2049 n387 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_27__1_ (clk n286 NeTt_2050 n739 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_27__0_ (clk n285 NeTt_2051 n372 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_28__1_ (clk n284 NeTt_2052 n738 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_2__1_ (clk n336 NeTt_2053 n764 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_2__0_ (clk n335 NeTt_2054 n362 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_29__1_ (clk n282 NeTt_2055 n737 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_29__0_ (clk n281 NeTt_2056 n376 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_5__1_ (clk n330 NeTt_2057 n761 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_26__1_ (clk n288 NeTt_2058 n740 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_26__0_ (clk n287 NeTt_2059 n356 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_28__0_ (clk n283 NeTt_2060 n374 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_3__1_ (clk n334 NeTt_2061 n763 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_3__0_ (clk n333 NeTt_2062 n389 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_4__1_ (clk n332 NeTt_2063 n762 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_4__0_ (clk n331 NeTt_2064 n391 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_6__1_ (clk n328 NeTt_2065 n760 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_6__0_ (clk n327 NeTt_2066 n364 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_25__1_ (clk n290 NeTt_2067 n741 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_25__0_ (clk n289 NeTt_2068 n370 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_22__1_ (clk n296 NeTt_2069 n744 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_22__0_ (clk n295 NeTt_2070 n352 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_21__1_ (clk n298 NeTt_2071 n745 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_21__0_ (clk n297 NeTt_2072 n413 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_20__1_ (clk n300 NeTt_2073 n746 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_19__1_ (clk n302 NeTt_2074 n747 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_19__0_ (clk n301 NeTt_2075 n411 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_20__0_ (clk n299 NeTt_2076 n350 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_18__1_ (clk n304 NeTt_2077 n748 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_13__1_ (clk n314 NeTt_2078 n753 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_13__0_ (clk n313 NeTt_2079 n405 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_18__0_ (clk n303 NeTt_2080 n348 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_17__1_ (clk n306 NeTt_2081 n749 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_17__0_ (clk n305 NeTt_2082 n409 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_14__1_ (clk n312 NeTt_2083 n752 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_10__1_ (clk n320 NeTt_2084 n756 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_10__0_ (clk n319 NeTt_2085 n366 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_14__0_ (clk n311 NeTt_2086 n344 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_12__1_ (clk n316 NeTt_2087 n754 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_11__1_ (clk n318 NeTt_2088 n755 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_11__0_ (clk n317 NeTt_2089 n401 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    prediction_table_reg_12__0_ (clk n315 NeTt_2090 n403 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U666 (N25 n693 n602 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U574 (n602 n603 prediction inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U665 (n648 n694 n603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U663 (n690 N24 n692 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U662 (n669 n359 n691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U664 (n692 n691 n693 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U660 (n687 N23 n689 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U659 (n678 n28 n688 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U661 (n689 n688 n690 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U656 (n681 n33 n685 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U657 (n684 n2 n686 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U658 (n686 n685 n687 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U654 (n726 N21 n683 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U653 (n725 n342 n682 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U655 (n683 n682 n684 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U651 (n724 N21 n680 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U650 (n723 n342 n679 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U652 (n680 n679 n681 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U648 (n675 n2 n677 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U647 (n672 n33 n676 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U649 (n677 n676 n678 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U645 (n722 N21 n674 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U644 (n721 n342 n673 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U646 (n674 n673 n675 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U642 (n720 N21 n671 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U641 (n719 n342 n670 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U643 (n671 n670 n672 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U639 (n666 N23 n668 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U638 (n657 n28 n667 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U640 (n668 n667 n669 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U636 (n663 n2 n665 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U635 (n660 n33 n664 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U637 (n665 n664 n666 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U633 (n718 N21 n662 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U632 (n717 n342 n661 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U634 (n662 n661 n663 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U630 (n716 N21 n659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U629 (n715 n342 n658 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U631 (n659 n658 n660 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U627 (n654 n2 n656 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U626 (n651 n33 n655 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U628 (n656 n655 n657 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U624 (n714 N21 n653 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U623 (n713 n342 n652 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U625 (n653 n652 n654 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U621 (n712 N21 n650 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U620 (n711 n342 n649 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U622 (n650 n649 n651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U618 (n645 N24 n647 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U617 (n624 n359 n646 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U619 (n647 n646 n648 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U615 (n642 N23 n644 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U614 (n633 n28 n643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U616 (n644 n643 n645 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U612 (n639 n2 n641 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U611 (n636 n33 n640 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U613 (n641 n640 n642 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U609 (n710 N21 n638 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U608 (n709 n342 n637 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U610 (n638 n637 n639 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U606 (n708 N21 n635 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U605 (n707 n342 n634 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U607 (n635 n634 n636 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U603 (n630 n2 n632 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U602 (n627 n33 n631 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U604 (n632 n631 n633 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U600 (n706 N21 n629 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U599 (n705 n342 n628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U601 (n629 n628 n630 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U597 (n704 N21 n626 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U596 (n703 n342 n625 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U598 (n626 n625 n627 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U594 (n621 N23 n623 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U593 (n612 n28 n622 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U595 (n623 n622 n624 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U591 (n618 n2 n620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U590 (n615 n33 n619 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U592 (n620 n619 n621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U588 (n702 N21 n617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U587 (n701 n342 n616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U589 (n617 n616 n618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U585 (n700 N21 n614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U584 (n699 n342 n613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U586 (n614 n613 n615 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U582 (n609 n2 n611 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U581 (n606 n33 n610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U583 (n611 n610 n612 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U579 (n698 N21 n608 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U578 (n697 n342 n607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U580 (n608 n607 n609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U576 (n696 N21 n605 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U575 (n695 n342 n604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U577 (n605 n604 n606 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U570 (n598 N20 n417 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U386 (n417 n418 N26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U567 (n595 n42 n597 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U566 (n574 n41 n596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U521 (n529 n41 n551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U568 (n597 n596 n598 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U564 (n592 N18 n594 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U563 (n583 n40 n593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U542 (n562 n40 n572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U565 (n594 n593 n595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U561 (n589 N17 n591 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U560 (n586 n732 n590 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U562 (n591 n590 n592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U558 (n726 N16 n588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U557 (n725 n6 n587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U559 (n588 n587 n589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U555 (n724 N16 n585 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U554 (n723 n600 n584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U556 (n585 n584 n586 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U551 (n577 n732 n581 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U552 (n580 n380 n582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U553 (n582 n581 n583 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U549 (n722 N16 n579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U548 (n721 n600 n578 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U550 (n579 n578 n580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U546 (n720 N16 n576 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U545 (n719 n600 n575 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U547 (n576 n575 n577 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U543 (n571 N18 n573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U544 (n573 n572 n574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U540 (n568 N17 n570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U539 (n565 n379 n569 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U541 (n570 n569 n571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U537 (n718 N16 n567 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U536 (n717 n600 n566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U538 (n567 n566 n568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U534 (n716 N16 n564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U533 (n715 n600 n563 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U535 (n564 n563 n565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U531 (n559 n380 n561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U530 (n556 n599 n560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U532 (n561 n560 n562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U528 (n714 N16 n558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U527 (n713 n731 n557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U529 (n558 n557 n559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U525 (n712 N16 n555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U524 (n711 n731 n554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U526 (n555 n554 n556 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U569 (n553 n772 n418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U522 (n550 N19 n552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U523 (n552 n551 n553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U519 (n547 N18 n549 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U518 (n538 n601 n548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U520 (n549 n548 n550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U516 (n544 N17 n546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U515 (n541 n732 n545 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U517 (n546 n545 n547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U513 (n710 N16 n543 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U512 (n709 n6 n542 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U514 (n543 n542 n544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U510 (n708 N16 n540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U509 (n707 n600 n539 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U511 (n540 n539 n541 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U507 (n535 n380 n537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U506 (n532 n599 n536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U508 (n537 n536 n538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U504 (n706 N16 n534 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U503 (n705 n731 n533 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U505 (n534 n533 n535 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U501 (n704 N16 n531 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U500 (n703 n6 n530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U502 (n531 n530 n532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U498 (n526 N18 n528 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U497 (n517 n601 n527 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U499 (n528 n527 n529 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U495 (n523 n4 n525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U494 (n520 n18 n524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U485 (n511 n18 n515 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U496 (n525 n524 n526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U492 (n702 N16 n522 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U491 (n701 n600 n521 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U493 (n522 n521 n523 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U489 (n700 N16 n519 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U488 (n699 n6 n518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U490 (n519 n518 n520 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U486 (n514 n380 n516 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U487 (n516 n515 n517 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U483 (n698 N16 n513 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U482 (n697 n6 n512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U484 (n513 n512 n514 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U319 (n7 n258 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U321 (n260 N27 n259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U320 (n767 n259 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U323 (n262 n769 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (N26 n3 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U324 (n263 branch_MEM n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (n270 n360 n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U332 (n271 N26 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U331 (n769 N27 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U330 (n268 n269 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U329 (n7 n267 n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U385 (n415 n416 N27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U477 (n463 n772 n416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U478 (n508 N20 n415 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U474 (n484 n41 n506 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U475 (n505 n42 n507 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U430 (n460 n42 n462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U476 (n507 n506 n508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U472 (n502 N18 n504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U471 (n493 n5 n503 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U450 (n472 n5 n482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U473 (n504 n503 n505 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U469 (n499 N17 n501 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U468 (n496 n599 n500 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U470 (n501 n500 n502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U466 (n377 N16 n498 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U465 (n357 n6 n497 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U467 (n498 n497 n499 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U463 (n375 N16 n495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U462 (n373 n600 n494 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U464 (n495 n494 n496 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U460 (n490 N17 n492 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U459 (n487 n379 n491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U438 (n466 n379 n470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U461 (n492 n491 n493 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U457 (n371 N16 n489 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U456 (n355 n600 n488 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U458 (n489 n488 n490 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U454 (n369 N16 n486 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U453 (n353 n600 n485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U455 (n486 n485 n487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U451 (n481 N18 n483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U452 (n483 n482 n484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U447 (n475 n599 n479 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U448 (n478 n380 n480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U449 (n480 n479 n481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U445 (n367 N16 n477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U444 (n351 n6 n476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U446 (n477 n476 n478 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U442 (n412 N16 n474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U441 (n349 n6 n473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U443 (n474 n473 n475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U439 (n469 n380 n471 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U440 (n471 n470 n472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U436 (n410 N16 n468 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U435 (n347 n731 n467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U411 (n365 n731 n443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U437 (n468 n467 n469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U433 (n408 N16 n465 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U432 (n345 n600 n464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U434 (n465 n464 n466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U429 (n439 n41 n461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U431 (n462 n461 n463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U427 (n457 N18 n459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U426 (n448 n601 n458 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U428 (n459 n458 n460 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U424 (n454 n380 n456 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U423 (n451 n18 n455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U425 (n456 n455 n457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U421 (n406 N16 n453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U420 (n343 n600 n452 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U422 (n453 n452 n454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U418 (n404 N16 n450 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U417 (n402 n600 n449 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U419 (n450 n449 n451 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U415 (n445 n380 n447 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U414 (n442 n599 n446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U416 (n447 n446 n448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U412 (n400 N16 n444 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U413 (n444 n443 n445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U480 (n696 N16 n510 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U481 (n510 n509 n511 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U479 (n695 n600 n509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U409 (n398 N16 n441 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U410 (n441 n440 n442 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U408 (n396 n731 n440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U316 (n599 n5 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U235 (n7 n197 n194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U236 (n773 n96 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U231 (n398 n14 n192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U230 (n194 n729 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U229 (n193 n192 n321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n14 n704 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U233 (n381 n194 n196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U232 (n195 n196 n322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n396 n13 n198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U238 (n200 n729 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n199 n198 n323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U242 (n13 n703 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U241 (n200 n768 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n201 n202 n324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U406 (n436 N18 n438 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U407 (n438 n437 n439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U405 (n427 n40 n437 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U402 (n430 n599 n434 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U403 (n433 N17 n435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U404 (n435 n434 n436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U400 (n394 N16 n432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U399 (n363 n6 n431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U401 (n432 n431 n433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U397 (n392 N16 n429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U396 (n390 n6 n428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U398 (n429 n428 n430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U393 (n421 n599 n425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U394 (n424 n380 n426 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U395 (n426 n425 n427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U391 (n388 N16 n423 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U390 (n361 n600 n422 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U392 (n423 n422 n424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U388 (n386 N16 n420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U387 (n384 n6 n419 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U389 (n420 n419 n421 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U253 (n211 n382 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n341 n54 n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U256 (n4 N16 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U306 (n5 n6 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U286 (n732 n600 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U249 (n394 n30 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U248 (n208 n729 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U247 (n206 n207 n325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (n208 n414 n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (n702 n30 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U250 (n209 n210 n326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U269 (n392 n37 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n222 n729 n221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (n220 n221 n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (is_branch_MEM n205 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U341 (n276 is_branch_MEM n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U113 (n105 is_branch_MEM n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U179 (n155 is_branch_MEM n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (n773 n103 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (n8 n203 n200 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U276 (n379 N16 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U296 (n601 N16 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U266 (n4 n6 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U328 (n257 n414 n265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U336 (n9 n695 n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (n264 n265 n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U318 (n257 n729 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U326 (n384 n9 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U317 (n256 n255 n339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n11 n726 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (n381 n50 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n51 n52 n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n377 n11 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (n50 n729 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n47 n48 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U175 (n727 n150 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U176 (n711 n20 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U174 (n151 n152 n308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (n150 n729 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U173 (n345 n20 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n148 n149 n307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n158 n768 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n710 n38 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n159 n160 n310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n158 n729 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U183 (n406 n38 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U181 (n156 n157 n309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n108 n414 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U120 (n718 n45 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (n109 n110 n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n108 n729 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n367 n45 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n106 n107 n293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n381 n99 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n16 n719 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n100 n101 n292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n99 n729 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n353 n16 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n97 n98 n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n725 n46 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n381 n57 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (n58 n59 n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (n357 n46 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U58 (n57 n729 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n55 n56 n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U311 (n250 n381 n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U312 (n696 n36 n251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U310 (n251 n252 n338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U308 (n250 n729 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U309 (n386 n36 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U307 (n248 n249 n337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U85 (n381 n78 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n722 n39 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (n79 n80 n286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (n371 n39 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n78 n729 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n76 n77 n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n54 n771 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n8 n53 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n8 n60 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n61 n771 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U264 (n61 n774 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U263 (n218 n382 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U178 (n770 n103 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n54 n770 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n382 n111 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U177 (n153 n733 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U338 (n774 n103 n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (n273 n382 n257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n103 n771 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n382 n102 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U188 (n54 n773 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n733 n161 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U314 (n774 n96 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U313 (n253 n733 n250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n733 n81 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n82 n771 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U261 (n215 n414 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U258 (n215 n729 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U301 (n727 n243 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n72 n73 n284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n727 n71 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U302 (n697 n12 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U300 (n244 n245 n336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U298 (n243 n729 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U299 (n361 n12 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U297 (n241 n242 n335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n35 n724 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n64 n1 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n65 n66 n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n375 n35 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n64 n729 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U65 (n62 n63 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n700 n37 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U271 (n222 n1 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U270 (n223 n224 n330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n85 n414 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n721 n27 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U92 (n86 n87 n288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n85 n729 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (n355 n27 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n83 n84 n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (n32 n723 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n373 n32 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n71 n729 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n69 n70 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U284 (n341 n75 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U283 (nreset n232 n229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (n75 n770 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (nreset n129 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U291 (n236 n1 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U292 (n23 n698 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U290 (n237 n238 n334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U288 (n236 n729 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U289 (n388 n23 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U287 (n234 n235 n333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (n229 n1 n231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U282 (n10 n699 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U280 (n230 n231 n332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U278 (n229 n729 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (n390 n10 n227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (n228 n227 n331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n382 n173 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U204 (n773 n68 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n770 n68 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n7 n123 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U170 (n770 n96 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n147 n7 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n96 n771 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n733 n95 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U212 (n773 n75 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (n179 n8 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n8 n185 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (n82 n773 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U154 (n82 n770 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (n7 n135 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U228 (n773 n89 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n7 n191 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U196 (n61 n773 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U195 (n733 n167 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n61 n770 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n733 n117 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U304 (n341 n89 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U303 (n246 n382 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U71 (n8 n67 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n68 n771 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U274 (n341 n68 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n8 n225 n222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n771 n89 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n8 n88 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n74 n382 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n75 n771 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U294 (n341 n82 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (n733 n239 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U162 (n89 n770 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U161 (n7 n141 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U262 (n701 n29 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U259 (n363 n29 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U260 (n216 n217 n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U257 (n213 n214 n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n17 n720 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U99 (n369 n17 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n727 n92 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (n92 n729 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n93 n94 n290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n90 n91 n289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n717 n26 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (n114 n414 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (n115 n116 n296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n114 n729 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (n351 n26 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n112 n113 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n716 n25 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (n412 n25 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n768 n120 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n120 n729 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U134 (n121 n122 n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n118 n119 n297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n24 n715 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U141 (n349 n24 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n126 n727 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n126 n729 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n127 n128 n300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n133 n134 n302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n727 n132 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U148 (n132 n729 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n410 n34 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n34 n714 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U147 (n130 n131 n301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (n124 n125 n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n22 n713 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n138 n1 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n139 n140 n304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (n170 n729 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n171 n172 n314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (n170 n1 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (n404 n31 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U202 (n31 n708 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n168 n169 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n138 n729 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n347 n22 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U155 (n136 n137 n303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (n21 n712 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n408 n21 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (n144 n414 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n144 n729 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n145 n146 n306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n142 n143 n305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n709 n19 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n164 n414 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U192 (n165 n166 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (n189 n190 n320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n188 n414 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n188 n729 n187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (n365 n383 n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (n705 n383 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U221 (n186 n187 n319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n164 n729 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U191 (n343 n19 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U189 (n162 n163 n311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n706 n15 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n400 n15 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U216 (n183 n184 n318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (n182 n729 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U209 (n44 n768 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (n177 n178 n316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n707 n43 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U217 (n768 n182 n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n181 n180 n317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U205 (n174 n175 n315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U206 (n44 n729 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n402 n43 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U667 (N25 n694 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (N22 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U353 (N24 n359 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (N23 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n33 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U344 (N21 n342 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U572 (N16 n600 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U713 (N20 n772 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U571 (n4 n599 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U705 (N17 n732 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U704 (N16 n731 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U573 (N18 n601 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U702 (n730 n729 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U703 (n49 n730 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U708 (n261 n767 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U709 (n266 n768 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U716 (N19 n775 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (N19 n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n360 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U710 (n270 n769 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U354 (N27 n360 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n734 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U376 (n399 n398 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U677 (n757 n704 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U366 (n728 n381 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U375 (n397 n396 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U676 (n758 n703 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U701 (n768 n728 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U365 (n18 n380 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U343 (n275 n341 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U367 (n734 n382 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U374 (n395 n394 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U384 (n728 n414 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U675 (n759 n702 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U373 (n393 n392 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U714 (n204 n773 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U712 (n104 n771 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U711 (n154 n770 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U717 (n274 n776 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (n734 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n194 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (n775 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U715 (n275 n774 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (n200 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U700 (n728 n727 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n728 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U707 (nreset n734 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U706 (n734 n733 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (N16 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (N18 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (N18 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (N17 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U364 (N17 n379 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n379 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (n208 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U668 (n766 n695 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U369 (n385 n384 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U699 (n735 n726 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U363 (n378 n377 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U684 (n750 n711 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U346 (n346 n345 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U683 (n751 n710 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U380 (n407 n406 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U691 (n743 n718 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U358 (n368 n367 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U692 (n742 n719 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U350 (n354 n353 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U698 (n736 n725 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U352 (n358 n357 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U669 (n765 n696 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U370 (n387 n386 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U695 (n739 n722 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U360 (n372 n371 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n257 n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n50 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (n150 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n99 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n108 n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (n158 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (n57 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (n250 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (n215 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (n78 n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U670 (n764 n697 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U355 (n362 n361 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U697 (n737 n724 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U362 (n376 n375 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n222 n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U673 (n761 n700 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U694 (n740 n721 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U351 (n356 n355 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U696 (n738 n723 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U361 (n374 n373 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (n126 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U671 (n763 n698 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U371 (n389 n388 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U672 (n762 n699 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U372 (n391 n390 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n170 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (n120 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (n144 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n92 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n176 n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (n43 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n182 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (n132 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U368 (n188 n383 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n243 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n64 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n85 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (n71 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n236 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n229 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U674 (n760 n701 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U356 (n364 n363 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U693 (n741 n720 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U359 (n370 n369 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U690 (n744 n717 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U349 (n352 n351 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U689 (n745 n716 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U383 (n413 n412 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U688 (n746 n715 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U687 (n747 n714 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U382 (n411 n410 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U348 (n350 n349 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U686 (n748 n713 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U681 (n753 n708 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U379 (n405 n404 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U347 (n348 n347 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U685 (n749 n712 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U381 (n409 n408 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U682 (n752 n709 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U678 (n756 n705 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U357 (n366 n365 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U345 (n344 n343 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U680 (n754 n707 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (n114 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (n138 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n164 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U679 (n755 n706 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U377 (n401 n400 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U378 (n403 n402 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U322 (n260 n3 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U334 (n272 branch_MEM n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U335 (N26 n3 n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U315 (n254 n731 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U255 (n212 n40 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U305 (n247 n732 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U285 (n233 n40 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U246 (N20 n775 n205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U342 (N20 n42 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n772 n775 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (n772 n42 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U339 (N16 n776 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U340 (N18 n4 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U295 (n240 n18 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U275 (n226 n601 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U265 (n219 n5 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    Thru6 (PC_incr_IF\<1\> N22) iprobe
    Thru9 (PC_incr_IF\<4\> N25) iprobe
    Thru5 (PC_incr_IF\<0\> N21) iprobe
    Thru8 (PC_incr_IF\<3\> N24) iprobe
    Thru7 (PC_incr_IF\<2\> N23) iprobe
    Thru4 (PC_incr_MEM\<4\> N20) iprobe
    Thru0 (PC_incr_MEM\<0\> N16) iprobe
    Thru3 (PC_incr_MEM\<3\> N19) iprobe
    Thru2 (PC_incr_MEM\<2\> N18) iprobe
    Thru1 (PC_incr_MEM\<1\> N17) iprobe
ends branch_predictor_prediction_window5_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: instruction_fetch
// View name: schematic
subckt soc_no_opt_16may_instruction_fetch_schematic clk nreset init_sleep \
        sleep control_transfer new_PC\<10\> new_PC\<9\> new_PC\<8\> \
        new_PC\<7\> new_PC\<6\> new_PC\<5\> new_PC\<4\> new_PC\<3\> \
        new_PC\<2\> new_PC\<1\> new_PC\<0\> stall instruction_o\<31\> \
        instruction_o\<30\> instruction_o\<29\> instruction_o\<28\> \
        instruction_o\<27\> instruction_o\<26\> instruction_o\<25\> \
        instruction_o\<24\> instruction_o\<23\> instruction_o\<22\> \
        instruction_o\<21\> instruction_o\<20\> instruction_o\<19\> \
        instruction_o\<18\> instruction_o\<17\> instruction_o\<16\> \
        instruction_o\<15\> instruction_o\<14\> instruction_o\<13\> \
        instruction_o\<12\> instruction_o\<11\> instruction_o\<10\> \
        instruction_o\<9\> instruction_o\<8\> instruction_o\<7\> \
        instruction_o\<6\> instruction_o\<5\> instruction_o\<4\> \
        instruction_o\<3\> instruction_o\<2\> instruction_o\<1\> \
        instruction_o\<0\> branch_target_out\<10\> branch_target_out\<9\> \
        branch_target_out\<8\> branch_target_out\<7\> \
        branch_target_out\<6\> branch_target_out\<5\> \
        branch_target_out\<4\> branch_target_out\<3\> \
        branch_target_out\<2\> branch_target_out\<1\> \
        branch_target_out\<0\> current_PC\<10\> current_PC\<9\> \
        current_PC\<8\> current_PC\<7\> current_PC\<6\> current_PC\<5\> \
        current_PC\<4\> current_PC\<3\> current_PC\<2\> current_PC\<1\> \
        current_PC\<0\> branched PC_incr_out\<10\> PC_incr_out\<9\> \
        PC_incr_out\<8\> PC_incr_out\<7\> PC_incr_out\<6\> \
        PC_incr_out\<5\> PC_incr_out\<4\> PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> \
        PC_incr_MEM\<10\> PC_incr_MEM\<9\> PC_incr_MEM\<8\> \
        PC_incr_MEM\<7\> PC_incr_MEM\<6\> PC_incr_MEM\<5\> \
        PC_incr_MEM\<4\> PC_incr_MEM\<3\> PC_incr_MEM\<2\> \
        PC_incr_MEM\<1\> PC_incr_MEM\<0\> branch_MEM is_branch_MEM \
        imem_address\<10\> imem_address\<9\> imem_address\<8\> \
        imem_address\<7\> imem_address\<6\> imem_address\<5\> \
        imem_address\<4\> imem_address\<3\> imem_address\<2\> \
        imem_address\<1\> imem_address\<0\> instruction\<31\> \
        instruction\<30\> instruction\<29\> instruction\<28\> \
        instruction\<27\> instruction\<26\> instruction\<25\> \
        instruction\<24\> instruction\<23\> instruction\<22\> \
        instruction\<21\> instruction\<20\> instruction\<19\> \
        instruction\<18\> instruction\<17\> instruction\<16\> \
        instruction\<15\> instruction\<14\> instruction\<13\> \
        instruction\<12\> instruction\<11\> instruction\<10\> \
        instruction\<9\> instruction\<8\> instruction\<7\> \
        instruction\<6\> instruction\<5\> instruction\<4\> \
        instruction\<3\> instruction\<2\> instruction\<1\> \
        instruction\<0\> inh_gnd inh_gnds inh_vdd_rename inh_vdds
    Vinstruction_fetch (inh_vdd_rename inh_vdd) vsource dc=0 type=dc
    U176 (n131 n160 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U171 (n126 n155 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U175 (instruction\<3\> n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U158 (n23 n142 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U169 (n65 n153 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U168 (n72 n152 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U167 (n79 n151 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U166 (n86 n150 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U165 (n93 n149 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U164 (n100 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U163 (n114 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U162 (n58 n146 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U161 (n51 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U159 (n107 n143 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U160 (n42 n144 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n9 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (PC_we n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U174 (n41 n158 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U177 (instruction\<0\> n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U172 (init_sleep n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (n132 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U170 (n119 n154 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U151 (n50 n135 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U155 (n49 n139 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U156 (n139 n140 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U148 (control_transfer n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U9 (n132 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U173 (n120 n157 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (n135 n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U152 (n135 n136 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U157 (n142 n141 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U150 (n133 n134 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U149 (relevant_imm_3 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n11 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (relevant_imm_2 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n30 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n6 n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U154 (n137 current_PC\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U153 (n162 n137 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (n16 current_PC\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n164 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (n14 current_PC\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n163 n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (current_PC\<3\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (n19 PC_incr_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n166 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (n3 PC_incr_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (n165 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (n142 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U142 (branch_prediction n125 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U140 (n125 instruction\<2\> n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U84 (PC_incr_out\<6\> n5 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (PC_incr_MEM\<6\> n140 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n70 n71 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (new_PC\<6\> n8 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (branch_target_out\<6\> n154 n69 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U79 (n69 n68 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U91 (PC_incr_out\<5\> n5 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (PC_incr_MEM\<5\> n140 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n77 n78 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (new_PC\<5\> n8 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (branch_target_out\<5\> n154 n76 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U86 (n76 n75 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U98 (n166 n5 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (n140 PC_incr_MEM\<4\> n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n85 n84 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (new_PC\<4\> n8 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (branch_target_out\<4\> n154 n83 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U93 (n83 n82 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (PC_incr_out\<3\> n5 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (PC_incr_MEM\<3\> n140 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n91 n92 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (new_PC\<3\> n8 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (branch_target_out\<3\> n154 n90 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U100 (n90 n89 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U112 (n136 PC_incr_out\<2\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (n49 PC_incr_MEM\<2\> n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n99 n98 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (new_PC\<2\> n8 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (branch_target_out\<2\> n154 n97 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U107 (n97 n96 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U119 (n136 PC_incr_out\<1\> n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (PC_incr_MEM\<1\> n140 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n105 n106 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (new_PC\<1\> n8 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (branch_target_out\<1\> n154 n104 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U114 (n103 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (PC_incr_out\<0\> n136 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U133 (PC_incr_MEM\<0\> n140 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (n122 n123 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (new_PC\<0\> n8 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (branch_target_out\<0\> n154 n118 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U128 (n117 n118 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n136 PC_incr_out\<7\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (PC_incr_MEM\<7\> n140 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n64 n63 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (new_PC\<7\> n8 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (branch_target_out\<7\> n154 n62 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U72 (n62 n61 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U70 (n136 PC_incr_out\<8\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (PC_incr_MEM\<8\> n140 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n56 n57 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (new_PC\<8\> n8 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (branch_target_out\<8\> n154 n55 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U65 (n55 n54 n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U126 (PC_incr_out\<10\> n5 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (PC_incr_MEM\<10\> n140 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n112 n113 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (PC_incr_MEM\<9\> n140 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U61 (n47 n48 n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (PC_incr_out\<9\> n5 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (new_PC\<10\> n8 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (branch_target_out\<10\> n154 n111 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U121 (n110 n111 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U60 (new_PC\<9\> n8 n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U59 (branch_target_out\<9\> n154 n46 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U58 (n46 n45 n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n158 n156 PC_we inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (instruction\<1\> n130 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (instruction\<6\> instruction\<5\> n129 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NADN2x1_PB4_AFBB
    U130 (n120 n121 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n155 n142 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (instruction\<24\> n141 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (instruction\<11\> n142 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U22 (n21 n22 relevant_imm_3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U27 (instruction\<23\> n141 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U26 (instruction\<10\> n142 n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U25 (n24 n25 relevant_imm_2 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (instruction\<20\> n141 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n39 n40 relevant_imm\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (instruction\<7\> n142 n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (instruction\<31\> n142 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (instruction\<21\> n13 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n28 n29 relevant_imm_0 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (instruction\<8\> n142 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (instruction\<22\> n13 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (instruction\<9\> n142 n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U28 (n26 n27 relevant_imm_1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (instruction\<12\> n141 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n38 n7 relevant_imm\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (instruction\<13\> n141 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n37 n7 relevant_imm\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (instruction\<14\> n141 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n7 n36 relevant_imm\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (instruction\<15\> n141 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n35 n7 relevant_imm\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (instruction\<16\> n141 n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n34 n7 relevant_imm\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (instruction\<17\> n13 n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n7 n33 relevant_imm\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (instruction\<18\> n13 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n32 n7 relevant_imm\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n31 n7 relevant_imm\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (instruction\<19\> n13 n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    boj_target_adder (current_PC\<10\> n162 current_PC\<8\> \
        current_PC\<7\> n163 n164 current_PC\<4\> n2 current_PC\<2\> \
        current_PC\<1\> current_PC\<0\> instruction\<31\> \
        relevant_imm\<18\> relevant_imm\<17\> relevant_imm\<16\> \
        relevant_imm\<15\> relevant_imm\<14\> relevant_imm\<13\> \
        relevant_imm\<12\> relevant_imm\<11\> relevant_imm\<10\> \
        instruction\<30\> instruction\<29\> instruction\<28\> \
        instruction\<27\> instruction\<26\> instruction\<25\> n134 n12 \
        relevant_imm_1 relevant_imm_0 branch_target_out\<10\> \
        branch_target_out\<9\> branch_target_out\<8\> \
        branch_target_out\<7\> branch_target_out\<6\> \
        branch_target_out\<5\> branch_target_out\<4\> \
        branch_target_out\<3\> branch_target_out\<2\> \
        branch_target_out\<1\> branch_target_out\<0\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) soc_no_opt_16may_branch_target_adder_schematic
    U147 (instruction\<3\> instruction\<2\> n131 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U141 (n127 n160 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (n124 n159 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (n66 n67 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (n73 n74 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (n80 n81 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n87 n88 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n94 n95 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (n101 n102 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U127 (n115 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (n59 n60 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (n52 n53 n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (n108 n109 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U57 (n43 n44 n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U56 (stall sleep n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U146 (n161 instruction\<4\> n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U143 (n128 n129 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (init_sleep n18 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U136 (n121 n157 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U134 (n8 n156 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U54 (n155 n157 branched inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    PC_incrementer (current_PC\<10\> current_PC\<9\> current_PC\<8\> \
        current_PC\<7\> current_PC\<6\> current_PC\<5\> current_PC\<4\> \
        current_PC\<3\> current_PC\<2\> current_PC\<1\> current_PC\<0\> \
        PC_incr_out\<10\> PC_incr_out\<9\> PC_incr_out\<8\> \
        PC_incr_out\<7\> PC_incr_out\<6\> n165 n166 PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> inh_gnd \
        inh_gnds inh_vdd inh_vdds) soc_no_opt_16may_PC_increment_schematic
    Thru31 (instruction\<0\> instruction_o\<0\>) iprobe
    Thru30 (instruction\<1\> instruction_o\<1\>) iprobe
    Thru29 (instruction\<2\> instruction_o\<2\>) iprobe
    Thru28 (instruction\<3\> instruction_o\<3\>) iprobe
    Thru27 (instruction\<4\> instruction_o\<4\>) iprobe
    Thru26 (instruction\<5\> instruction_o\<5\>) iprobe
    Thru25 (instruction\<6\> instruction_o\<6\>) iprobe
    Thru24 (instruction\<7\> instruction_o\<7\>) iprobe
    Thru23 (instruction\<8\> instruction_o\<8\>) iprobe
    Thru22 (instruction\<9\> instruction_o\<9\>) iprobe
    Thru21 (instruction\<10\> instruction_o\<10\>) iprobe
    Thru20 (instruction\<11\> instruction_o\<11\>) iprobe
    Thru19 (instruction\<12\> instruction_o\<12\>) iprobe
    Thru18 (instruction\<13\> instruction_o\<13\>) iprobe
    Thru17 (instruction\<14\> instruction_o\<14\>) iprobe
    Thru16 (instruction\<15\> instruction_o\<15\>) iprobe
    Thru15 (instruction\<16\> instruction_o\<16\>) iprobe
    Thru14 (instruction\<17\> instruction_o\<17\>) iprobe
    Thru13 (instruction\<18\> instruction_o\<18\>) iprobe
    Thru12 (instruction\<19\> instruction_o\<19\>) iprobe
    Thru11 (instruction\<20\> instruction_o\<20\>) iprobe
    Thru10 (instruction\<21\> instruction_o\<21\>) iprobe
    Thru9 (instruction\<22\> instruction_o\<22\>) iprobe
    Thru8 (instruction\<23\> instruction_o\<23\>) iprobe
    Thru7 (instruction\<24\> instruction_o\<24\>) iprobe
    Thru6 (instruction\<25\> instruction_o\<25\>) iprobe
    Thru5 (instruction\<26\> instruction_o\<26\>) iprobe
    Thru4 (instruction\<27\> instruction_o\<27\>) iprobe
    Thru3 (instruction\<28\> instruction_o\<28\>) iprobe
    Thru2 (instruction\<29\> instruction_o\<29\>) iprobe
    Thru1 (instruction\<30\> instruction_o\<30\>) iprobe
    Thru0 (instruction\<31\> instruction_o\<31\>) iprobe
    PC (clk n10 nreset current_PC\<10\> n162 current_PC\<8\> \
        current_PC\<7\> n163 n164 current_PC\<4\> current_PC\<3\> \
        current_PC\<2\> current_PC\<1\> current_PC\<0\> imem_address\<10\> \
        imem_address\<9\> imem_address\<8\> imem_address\<7\> \
        imem_address\<6\> imem_address\<5\> imem_address\<4\> \
        imem_address\<3\> imem_address\<2\> imem_address\<1\> \
        imem_address\<0\> n143 n144 n145 n146 n153 n152 n151 n150 n149 \
        n148 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        soc_no_opt_16may_PC_schematic
    branch_predictor (clk nreset PC_incr_out\<6\> PC_incr_out\<5\> \
        PC_incr_out\<4\> PC_incr_out\<3\> PC_incr_out\<2\> \
        PC_incr_MEM\<6\> PC_incr_MEM\<5\> PC_incr_MEM\<4\> \
        PC_incr_MEM\<3\> PC_incr_MEM\<2\> branch_prediction branch_MEM \
        is_branch_MEM inh_gnd inh_gnds inh_vdd inh_vdds) \
        branch_predictor_prediction_window5_schematic
ends soc_no_opt_16may_instruction_fetch_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: EXMEM_preg
// View name: schematic
subckt soc_no_opt_16may_EXMEM_preg_schematic clk flush ALU_result_in\<31\> \
        ALU_result_in\<30\> ALU_result_in\<29\> ALU_result_in\<28\> \
        ALU_result_in\<27\> ALU_result_in\<26\> ALU_result_in\<25\> \
        ALU_result_in\<24\> ALU_result_in\<23\> ALU_result_in\<22\> \
        ALU_result_in\<21\> ALU_result_in\<20\> ALU_result_in\<19\> \
        ALU_result_in\<18\> ALU_result_in\<17\> ALU_result_in\<16\> \
        ALU_result_in\<15\> ALU_result_in\<14\> ALU_result_in\<13\> \
        ALU_result_in\<12\> ALU_result_in\<11\> ALU_result_in\<10\> \
        ALU_result_in\<9\> ALU_result_in\<8\> ALU_result_in\<7\> \
        ALU_result_in\<6\> ALU_result_in\<5\> ALU_result_in\<4\> \
        ALU_result_in\<3\> ALU_result_in\<2\> ALU_result_in\<1\> \
        ALU_result_in\<0\> ALU_result_out\<31\> ALU_result_out\<30\> \
        ALU_result_out\<29\> ALU_result_out\<28\> ALU_result_out\<27\> \
        ALU_result_out\<26\> ALU_result_out\<25\> ALU_result_out\<24\> \
        ALU_result_out\<23\> ALU_result_out\<22\> ALU_result_out\<21\> \
        ALU_result_out\<20\> ALU_result_out\<19\> ALU_result_out\<18\> \
        ALU_result_out\<17\> ALU_result_out\<16\> ALU_result_out\<15\> \
        ALU_result_out\<14\> ALU_result_out\<13\> ALU_result_out\<12\> \
        ALU_result_out\<11\> ALU_result_out\<10\> ALU_result_out\<9\> \
        ALU_result_out\<8\> ALU_result_out\<7\> ALU_result_out\<6\> \
        ALU_result_out\<5\> ALU_result_out\<4\> ALU_result_out\<3\> \
        ALU_result_out\<2\> ALU_result_out\<1\> ALU_result_out\<0\> \
        rs2_data_in\<31\> rs2_data_in\<30\> rs2_data_in\<29\> \
        rs2_data_in\<28\> rs2_data_in\<27\> rs2_data_in\<26\> \
        rs2_data_in\<25\> rs2_data_in\<24\> rs2_data_in\<23\> \
        rs2_data_in\<22\> rs2_data_in\<21\> rs2_data_in\<20\> \
        rs2_data_in\<19\> rs2_data_in\<18\> rs2_data_in\<17\> \
        rs2_data_in\<16\> rs2_data_in\<15\> rs2_data_in\<14\> \
        rs2_data_in\<13\> rs2_data_in\<12\> rs2_data_in\<11\> \
        rs2_data_in\<10\> rs2_data_in\<9\> rs2_data_in\<8\> \
        rs2_data_in\<7\> rs2_data_in\<6\> rs2_data_in\<5\> \
        rs2_data_in\<4\> rs2_data_in\<3\> rs2_data_in\<2\> \
        rs2_data_in\<1\> rs2_data_in\<0\> rs2_data_out\<31\> \
        rs2_data_out\<30\> rs2_data_out\<29\> rs2_data_out\<28\> \
        rs2_data_out\<27\> rs2_data_out\<26\> rs2_data_out\<25\> \
        rs2_data_out\<24\> rs2_data_out\<23\> rs2_data_out\<22\> \
        rs2_data_out\<21\> rs2_data_out\<20\> rs2_data_out\<19\> \
        rs2_data_out\<18\> rs2_data_out\<17\> rs2_data_out\<16\> \
        rs2_data_out\<15\> rs2_data_out\<14\> rs2_data_out\<13\> \
        rs2_data_out\<12\> rs2_data_out\<11\> rs2_data_out\<10\> \
        rs2_data_out\<9\> rs2_data_out\<8\> rs2_data_out\<7\> \
        rs2_data_out\<6\> rs2_data_out\<5\> rs2_data_out\<4\> \
        rs2_data_out\<3\> rs2_data_out\<2\> rs2_data_out\<1\> \
        rs2_data_out\<0\> rs2_adr_in\<4\> rs2_adr_in\<3\> rs2_adr_in\<2\> \
        rs2_adr_in\<1\> rs2_adr_in\<0\> rs2_adr_out\<4\> rs2_adr_out\<3\> \
        rs2_adr_out\<2\> rs2_adr_out\<1\> rs2_adr_out\<0\> \
        branch_target_out\<10\> branch_target_out\<9\> \
        branch_target_out\<8\> branch_target_out\<7\> \
        branch_target_out\<6\> branch_target_out\<5\> \
        branch_target_out\<4\> branch_target_out\<3\> \
        branch_target_out\<2\> branch_target_out\<1\> \
        branch_target_out\<0\> branch_target_in\<10\> \
        branch_target_in\<9\> branch_target_in\<8\> branch_target_in\<7\> \
        branch_target_in\<6\> branch_target_in\<5\> branch_target_in\<4\> \
        branch_target_in\<3\> branch_target_in\<2\> branch_target_in\<1\> \
        branch_target_in\<0\> PC_incr_in\<10\> PC_incr_in\<9\> \
        PC_incr_in\<8\> PC_incr_in\<7\> PC_incr_in\<6\> PC_incr_in\<5\> \
        PC_incr_in\<4\> PC_incr_in\<3\> PC_incr_in\<2\> PC_incr_in\<1\> \
        PC_incr_in\<0\> PC_incr_out\<10\> PC_incr_out\<9\> \
        PC_incr_out\<8\> PC_incr_out\<7\> PC_incr_out\<6\> \
        PC_incr_out\<5\> PC_incr_out\<4\> PC_incr_out\<3\> \
        PC_incr_out\<2\> PC_incr_out\<1\> PC_incr_out\<0\> mem_we_in \
        mem_re_in mem_we_out mem_re_out mem_write_width_in\<1\> \
        mem_write_width_in\<0\> mem_write_width_out\<1\> \
        mem_write_width_out\<0\> is_branch_in is_branch_out is_jump_in \
        is_jump_out rd_in\<4\> rd_in\<3\> rd_in\<2\> rd_in\<1\> rd_in\<0\> \
        rd_we_in rd_out\<4\> rd_out\<3\> rd_out\<2\> rd_out\<1\> \
        rd_out\<0\> rd_we_out wb_src_in\<1\> wb_src_in\<0\> \
        wb_src_out\<1\> wb_src_out\<0\> mem_load_unsigned_in \
        mem_load_unsigned_out branched_in branched_out inh_gnd inh_gnds \
        inh_vdd inh_vdds
    rd_out_reg_2_ (clk N10 NeTt_595 n188 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_4_ (clk n193 NeTt_596 n186 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_3_ (clk n192 NeTt_597 n142 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_0_ (clk n215 NeTt_598 n98 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_out_reg_1_ (clk n216 NeTt_599 n140 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rd_we_out_reg (clk n210 NeTt_600 n138 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    is_branch_out_reg (clk n213 NeTt_601 n115 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branched_out_reg (clk n199 NeTt_602 n83 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_we_out_reg (clk n211 mem_we_out NeTt_603 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_re_out_reg (clk n212 mem_re_out NeTt_604 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    is_jump_out_reg (clk n214 is_jump_out NeTt_605 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_9_ (clk N28 NeTt_606 n152 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_5_ (clk n205 NeTt_607 n190 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_4_ (clk n204 NeTt_608 n184 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_0_ (clk n200 NeTt_609 n160 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_adr_out_reg_1_ (clk n195 rs2_adr_out\<1\> NeTt_610 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_1_ (clk n201 NeTt_611 n158 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_7_ (clk n207 NeTt_612 n156 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_8_ (clk n208 NeTt_613 n154 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_10_ (clk n209 NeTt_614 n150 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_adr_out_reg_2_ (clk n196 NeTt_615 n148 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_adr_out_reg_3_ (clk n197 NeTt_616 n118 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_adr_out_reg_0_ (clk n194 NeTt_617 n81 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_adr_out_reg_4_ (clk n198 NeTt_618 n146 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_2_ (clk n202 NeTt_619 n73 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_12_ (clk ALU_result_in\<12\> NeTt_620 n180 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_14_ (clk ALU_result_in\<14\> NeTt_621 n176 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_16_ (clk ALU_result_in\<16\> NeTt_622 n174 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_18_ (clk ALU_result_in\<18\> NeTt_623 n172 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_21_ (clk ALU_result_in\<21\> NeTt_624 n170 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_25_ (clk ALU_result_in\<25\> NeTt_625 n168 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_27_ (clk ALU_result_in\<27\> NeTt_626 n166 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_29_ (clk ALU_result_in\<29\> NeTt_627 n164 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_30_ (clk ALU_result_in\<30\> NeTt_628 n162 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_23_ (clk ALU_result_in\<23\> NeTt_629 n136 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_13_ (clk ALU_result_in\<13\> NeTt_630 n134 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_15_ (clk ALU_result_in\<15\> NeTt_631 n132 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_17_ (clk ALU_result_in\<17\> NeTt_632 n130 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_24_ (clk ALU_result_in\<24\> NeTt_633 n128 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_26_ (clk ALU_result_in\<26\> NeTt_634 n126 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_28_ (clk ALU_result_in\<28\> NeTt_635 n124 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_31_ (clk ALU_result_in\<31\> NeTt_636 n122 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_load_unsigned_out_reg (clk mem_load_unsigned_in NeTt_637 n120 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_7_ (clk ALU_result_in\<7\> NeTt_638 n113 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_10_ (clk ALU_result_in\<10\> NeTt_639 n111 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_2_ (clk ALU_result_in\<2\> NeTt_640 n109 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_3_ (clk ALU_result_in\<3\> NeTt_641 n107 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_5_ (clk ALU_result_in\<5\> NeTt_642 n105 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_1_ (clk ALU_result_in\<1\> NeTt_643 n103 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_22_ (clk ALU_result_in\<22\> NeTt_644 n96 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_9_ (clk ALU_result_in\<9\> NeTt_645 n93 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_0_ (clk ALU_result_in\<0\> NeTt_646 n91 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_4_ (clk ALU_result_in\<4\> NeTt_647 n89 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_19_ (clk ALU_result_in\<19\> NeTt_648 n87 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_20_ (clk ALU_result_in\<20\> NeTt_649 n85 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_6_ (clk ALU_result_in\<6\> NeTt_650 n79 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_8_ (clk ALU_result_in\<8\> NeTt_651 n77 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    ALU_result_out_reg_11_ (clk ALU_result_in\<11\> NeTt_652 n75 inh_gnd \
        inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_0_ (clk rs2_data_in\<0\> rs2_data_out\<0\> NeTt_653 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_1_ (clk rs2_data_in\<1\> rs2_data_out\<1\> NeTt_654 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_2_ (clk rs2_data_in\<2\> rs2_data_out\<2\> NeTt_655 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_3_ (clk rs2_data_in\<3\> rs2_data_out\<3\> NeTt_656 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_4_ (clk rs2_data_in\<4\> rs2_data_out\<4\> NeTt_657 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_5_ (clk rs2_data_in\<5\> rs2_data_out\<5\> NeTt_658 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_6_ (clk rs2_data_in\<6\> rs2_data_out\<6\> NeTt_659 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_7_ (clk rs2_data_in\<7\> rs2_data_out\<7\> NeTt_660 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_8_ (clk rs2_data_in\<8\> rs2_data_out\<8\> NeTt_661 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_9_ (clk rs2_data_in\<9\> rs2_data_out\<9\> NeTt_662 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_10_ (clk rs2_data_in\<10\> rs2_data_out\<10\> \
        NeTt_663 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_11_ (clk rs2_data_in\<11\> rs2_data_out\<11\> \
        NeTt_664 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_12_ (clk rs2_data_in\<12\> rs2_data_out\<12\> \
        NeTt_665 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_13_ (clk rs2_data_in\<13\> rs2_data_out\<13\> \
        NeTt_666 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_14_ (clk rs2_data_in\<14\> rs2_data_out\<14\> \
        NeTt_667 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_15_ (clk rs2_data_in\<15\> rs2_data_out\<15\> \
        NeTt_668 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_16_ (clk rs2_data_in\<16\> rs2_data_out\<16\> \
        NeTt_669 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_17_ (clk rs2_data_in\<17\> rs2_data_out\<17\> \
        NeTt_670 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_18_ (clk rs2_data_in\<18\> rs2_data_out\<18\> \
        NeTt_671 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_19_ (clk rs2_data_in\<19\> rs2_data_out\<19\> \
        NeTt_672 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_20_ (clk rs2_data_in\<20\> rs2_data_out\<20\> \
        NeTt_673 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_21_ (clk rs2_data_in\<21\> rs2_data_out\<21\> \
        NeTt_674 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_22_ (clk rs2_data_in\<22\> rs2_data_out\<22\> \
        NeTt_675 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_23_ (clk rs2_data_in\<23\> rs2_data_out\<23\> \
        NeTt_676 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_24_ (clk rs2_data_in\<24\> rs2_data_out\<24\> \
        NeTt_677 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_25_ (clk rs2_data_in\<25\> rs2_data_out\<25\> \
        NeTt_678 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_26_ (clk rs2_data_in\<26\> rs2_data_out\<26\> \
        NeTt_679 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_27_ (clk rs2_data_in\<27\> rs2_data_out\<27\> \
        NeTt_680 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_28_ (clk rs2_data_in\<28\> rs2_data_out\<28\> \
        NeTt_681 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_29_ (clk rs2_data_in\<29\> rs2_data_out\<29\> \
        NeTt_682 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_30_ (clk rs2_data_in\<30\> rs2_data_out\<30\> \
        NeTt_683 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    rs2_data_out_reg_31_ (clk rs2_data_in\<31\> rs2_data_out\<31\> \
        NeTt_684 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_6_ (clk n206 NeTt_685 n144 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    PC_incr_out_reg_3_ (clk n203 NeTt_686 n71 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_write_width_out_reg_1_ (clk mem_write_width_in\<1\> NeTt_687 n178 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    mem_write_width_out_reg_0_ (clk mem_write_width_in\<0\> NeTt_688 n182 \
        inh_gnd inh_gnds inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_src_out_reg_1_ (clk n95 wb_src_out\<1\> NeTt_689 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    wb_src_out_reg_0_ (clk n117 wb_src_out\<0\> NeTt_690 inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_0_ (clk branch_target_in\<0\> \
        branch_target_out\<0\> NeTt_691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_1_ (clk branch_target_in\<1\> \
        branch_target_out\<1\> NeTt_692 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_2_ (clk branch_target_in\<2\> \
        branch_target_out\<2\> NeTt_693 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_3_ (clk branch_target_in\<3\> \
        branch_target_out\<3\> NeTt_694 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_4_ (clk branch_target_in\<4\> \
        branch_target_out\<4\> NeTt_695 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_5_ (clk branch_target_in\<5\> \
        branch_target_out\<5\> NeTt_696 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_6_ (clk branch_target_in\<6\> \
        branch_target_out\<6\> NeTt_697 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_7_ (clk branch_target_in\<7\> \
        branch_target_out\<7\> NeTt_698 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_8_ (clk branch_target_in\<8\> \
        branch_target_out\<8\> NeTt_699 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_9_ (clk branch_target_in\<9\> \
        branch_target_out\<9\> NeTt_700 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_RFDFFx1_PB4_AFBB
    branch_target_out_reg_10_ (clk branch_target_in\<10\> \
        branch_target_out\<10\> NeTt_701 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_RFDFFx1_PB4_AFBB
    U62 (wb_src_in\<0\> n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U18 (wb_src_in\<1\> n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U116 (n188 rd_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U120 (rd_in\<2\> n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U114 (n186 rd_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U77 (n142 rd_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U20 (n98 rd_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U75 (n140 rd_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U74 (n138 rd_we_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U58 (n115 is_branch_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U12 (n83 branched_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U121 (PC_incr_in\<9\> n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U92 (n152 PC_incr_out\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U117 (n190 PC_incr_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U112 (n184 PC_incr_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U99 (n160 PC_incr_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U97 (n158 PC_incr_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U95 (n156 PC_incr_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U93 (n154 PC_incr_out\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U90 (n150 PC_incr_out\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U88 (n148 rs2_adr_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U63 (n118 rs2_adr_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U10 (n81 rs2_adr_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U86 (n146 rs2_adr_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n73 PC_incr_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U110 (n180 ALU_result_out\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U108 (n176 ALU_result_out\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U107 (n174 ALU_result_out\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U106 (n172 ALU_result_out\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U105 (n170 ALU_result_out\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U104 (n168 ALU_result_out\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U103 (n166 ALU_result_out\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U102 (n164 ALU_result_out\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U101 (n162 ALU_result_out\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U73 (n136 ALU_result_out\<23\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U72 (n134 ALU_result_out\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U71 (n132 ALU_result_out\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U70 (n130 ALU_result_out\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U69 (n128 ALU_result_out\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U68 (n126 ALU_result_out\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U67 (n124 ALU_result_out\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U66 (n122 ALU_result_out\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U65 (n120 mem_load_unsigned_out inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U30 (n113 ALU_result_out\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n111 ALU_result_out\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U28 (n109 ALU_result_out\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n107 ALU_result_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (n105 ALU_result_out\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n103 ALU_result_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (n96 ALU_result_out\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n93 ALU_result_out\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U16 (n91 ALU_result_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n89 ALU_result_out\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U14 (n87 ALU_result_out\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U13 (n85 ALU_result_out\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U8 (n79 ALU_result_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n77 ALU_result_out\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U6 (n75 ALU_result_out\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U119 (flush n217 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (flush n101 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (flush n100 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (flush n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (flush n102 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (n71 PC_incr_out\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U79 (n144 PC_incr_out\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U111 (n182 mem_write_width_out\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U109 (n178 mem_write_width_out\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U55 (rd_in\<4\> n101 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n217 rd_in\<3\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U32 (rd_in\<0\> n1 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (rd_in\<1\> n100 n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U37 (n1 rd_we_in n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U34 (n101 is_branch_in n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U49 (n100 branched_in n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U36 (n100 mem_we_in n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U35 (n102 mem_re_in n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U33 (n217 is_jump_in n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U39 (n219 n102 N28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U43 (n102 PC_incr_in\<5\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U44 (n101 PC_incr_in\<4\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U48 (n101 PC_incr_in\<0\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U53 (rs2_adr_in\<1\> n101 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U47 (n100 PC_incr_in\<1\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U41 (n100 PC_incr_in\<7\> n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U40 (n1 PC_incr_in\<8\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n217 PC_incr_in\<10\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U52 (n217 rs2_adr_in\<2\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U51 (n217 rs2_adr_in\<3\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n102 rs2_adr_in\<0\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U50 (rs2_adr_in\<4\> n1 n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U46 (n102 PC_incr_in\<2\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n1 PC_incr_in\<3\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U42 (n1 PC_incr_in\<6\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n52 n193 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U78 (n53 n192 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U21 (n30 n215 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U76 (n29 n216 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U82 (n35 n210 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U59 (n32 n213 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U83 (n46 n199 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U84 (n34 n211 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U81 (n33 n212 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U60 (n31 n214 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U118 (n40 n205 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U113 (n41 n204 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U100 (n45 n200 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U85 (n50 n195 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U98 (n44 n201 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U96 (n38 n207 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U94 (n37 n208 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U91 (n36 n209 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U89 (n49 n196 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U64 (n48 n197 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U11 (n51 n194 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U87 (n47 n198 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U61 (n43 n202 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U80 (n39 n206 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U9 (n42 n203 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx1_PB4_AFBB
    U57 (n218 flush N10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_EXMEM_preg_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: forwarder
// View name: schematic
subckt soc_no_opt_16may_forwarder_schematic rs1_ex\<4\> rs1_ex\<3\> \
        rs1_ex\<2\> rs1_ex\<1\> rs1_ex\<0\> rs2_ex\<4\> rs2_ex\<3\> \
        rs2_ex\<2\> rs2_ex\<1\> rs2_ex\<0\> rs2_mem\<4\> rs2_mem\<3\> \
        rs2_mem\<2\> rs2_mem\<1\> rs2_mem\<0\> rd_mem\<4\> rd_mem\<3\> \
        rd_mem\<2\> rd_mem\<1\> rd_mem\<0\> rd_wb\<4\> rd_wb\<3\> \
        rd_wb\<2\> rd_wb\<1\> rd_wb\<0\> rd_mem_we rd_wb_we mem_rs2_src \
        rs1_src\<1\> rs1_src\<0\> rs2_src\<1\> rs2_src\<0\> inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U155 (N17 n144 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (n149 n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (n8 mem_rs2_src inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U152 (n120 n141 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U150 (rs2_mem\<3\> n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U151 (rs2_mem\<4\> n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U149 (rs2_mem\<2\> n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U156 (n33 n145 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U158 (N5 n147 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U154 (N14 n143 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U126 (n97 n116 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U101 (n72 n92 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U157 (rd_mem_we n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U153 (N8 n142 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U159 (n29 n148 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U148 (rs2_mem\<1\> n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U125 (rd_wb\<0\> n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U4 (rd_wb\<4\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (rd_wb\<3\> n2 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U2 (rd_wb\<2\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U102 (rd_mem\<3\> n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U53 (rd_mem\<4\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U52 (rd_mem\<2\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U50 (rd_mem\<0\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U7 (n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (rd_wb\<1\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n5 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U99 (rs2_ex\<3\> n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U124 (rs2_ex\<1\> n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U100 (rs2_ex\<4\> n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U98 (rs2_ex\<2\> n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (rs1_ex\<4\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U48 (rs1_ex\<3\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U76 (n50 n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (n12 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U75 (rs1_ex\<1\> n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U47 (rs1_ex\<2\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U146 (n134 n133 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (n128 n127 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n137 n117 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n6 n117 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n119 n118 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U30 (n30 rd_wb_we n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U31 (n31 n32 n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U45 (n36 n37 n38 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n86 n85 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n111 n110 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n105 n104 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (n94 n6 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U105 (n114 n94 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U106 (n96 n95 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U20 (N11 n24 n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n80 n79 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U23 (rd_mem_we n24 n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n64 n63 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n114 n69 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U78 (rd_mem\<1\> n69 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n71 n70 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U24 (n27 n28 n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U127 (rs2_mem\<0\> n115 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (rs2_ex\<0\> n115 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U77 (n43 rs2_ex\<0\> n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U66 (n58 n57 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U55 (n4 n47 n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U56 (n67 n47 n48 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U57 (n49 n48 n50 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U38 (n20 n19 n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U12 (n67 n9 n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U11 (rd_mem\<1\> n9 n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U13 (n11 n10 n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U54 (n115 rs1_ex\<0\> n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U10 (rs1_ex\<0\> n43 n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U29 (n25 n144 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U135 (n124 n141 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U147 (n136 n135 N17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U144 (rd_wb\<3\> n139 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U143 (rs2_mem\<3\> n2 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U145 (n132 n131 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U141 (rd_wb\<4\> n140 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U140 (rs2_mem\<4\> n3 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U142 (n129 n130 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U137 (rd_wb\<2\> n138 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U136 (n1 rs2_mem\<2\> n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U138 (n125 n126 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U133 (n121 n137 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U132 (n121 n6 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U134 (n123 n122 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U34 (rd_wb\<1\> rd_wb\<0\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U32 (rd_wb\<2\> n145 n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U33 (rd_wb\<3\> rd_wb\<4\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U46 (n39 n38 N5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U43 (n41 rd_mem\<3\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U42 (rs1_ex\<3\> n93 n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U44 (n34 n35 n36 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (rs2_ex\<3\> n93 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U94 (rd_mem\<3\> n90 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U95 (n83 n84 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (rd_wb\<3\> n90 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U119 (rs2_ex\<3\> n2 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U121 (n108 n109 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U21 (n25 n143 rs2_src\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U111 (n101 n116 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U123 (n113 n112 N14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U116 (rs2_ex\<4\> n3 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U117 (rd_wb\<4\> n91 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U118 (n106 n107 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (rs2_ex\<2\> n1 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (rd_wb\<2\> n89 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n102 n103 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U108 (n98 n6 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U109 (n98 n114 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U110 (n100 n99 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (rd_mem\<4\> n91 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U90 (rs2_ex\<4\> n46 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (n82 n81 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U39 (rs1_ex\<4\> n46 n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U40 (rd_mem\<4\> n42 n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U41 (n21 n22 n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (n76 n92 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U97 (n88 n87 N11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U19 (n23 n146 rs2_src\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U28 (n25 n142 rs1_src\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U74 (n65 n66 N8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U22 (n26 n147 rs1_src\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U87 (rd_mem\<2\> n89 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U86 (rs2_ex\<2\> n45 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U88 (n77 n78 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U83 (n73 n114 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U82 (rd_mem\<1\> n73 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (n74 n75 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (rs1_ex\<3\> n2 n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (rd_wb\<3\> n41 n61 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n62 n61 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U67 (rs1_ex\<4\> n3 n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U68 (rd_wb\<4\> n42 n59 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U69 (n59 n60 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U25 (rd_mem\<2\> n148 n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U26 (rd_mem\<4\> rd_mem\<3\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U27 (rd_mem\<1\> rd_mem\<0\> n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U131 (n115 rs2_mem\<0\> n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U63 (rs1_ex\<2\> n1 n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U107 (n115 rs2_ex\<0\> n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U35 (n45 rs1_ex\<2\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U81 (n43 rs2_ex\<0\> n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U62 (n54 n68 n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (n56 n55 n57 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (rd_wb\<2\> n40 n55 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U60 (n51 n67 n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U59 (n51 n4 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U61 (n53 n52 n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U18 (n16 n44 n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U36 (rd_mem\<2\> n40 n17 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U37 (n18 n17 n19 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U16 (n13 n67 n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U15 (rd_mem\<1\> n13 n15 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U17 (n14 n15 n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U58 (n115 rs1_ex\<0\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U14 (n43 rs1_ex\<0\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_forwarder_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: alu_DW01_cmp2_1
// View name: schematic
subckt soc_no_opt_16may_alu_DW01_cmp2_1_schematic A\<31\> A\<30\> A\<29\> \
        A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> \
        A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> \
        A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> \
        A\<3\> A\<2\> A\<1\> A\<0\> B\<31\> B\<30\> B\<29\> B\<28\> \
        B\<27\> B\<26\> B\<25\> B\<24\> B\<23\> B\<22\> B\<21\> B\<20\> \
        B\<19\> B\<18\> B\<17\> B\<16\> B\<15\> B\<14\> B\<13\> B\<12\> \
        B\<11\> B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> \
        B\<2\> B\<1\> B\<0\> LEQ TC LT_LE GE_GT inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U10 (n63 n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U11 (n67 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (A\<29\> n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (B\<29\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (A\<28\> n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (B\<28\> n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (A\<27\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (B\<27\> n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (A\<26\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U53 (B\<26\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (B\<25\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n52 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (A\<24\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (B\<24\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (A\<23\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (B\<23\> n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (A\<22\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (B\<22\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (A\<21\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (B\<21\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (A\<20\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (B\<20\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (A\<19\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (B\<19\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (A\<18\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (B\<18\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (A\<17\> n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (B\<17\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (A\<16\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (B\<16\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (A\<15\> n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (B\<15\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (A\<14\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (B\<14\> n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (A\<13\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (B\<13\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (A\<12\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (B\<12\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (A\<11\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (B\<11\> n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (B\<31\> n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (B\<30\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (A\<25\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (A\<10\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (B\<9\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (A\<8\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (B\<8\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (A\<7\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (B\<7\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (A\<6\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (B\<6\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (A\<5\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (B\<5\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (A\<4\> n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (B\<4\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (A\<3\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (B\<3\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (A\<2\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (B\<2\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n183 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (A\<0\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U186 (n61 A\<31\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U62 (n10 n62 LT_LE inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U67 (n69 n68 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n60 A\<30\> n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (B\<28\> n57 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (n77 n76 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n2 A\<28\> n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U72 (n74 n75 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (B\<26\> n54 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (n85 n84 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (A\<26\> n53 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U79 (n83 n82 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (B\<24\> n50 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (n93 n92 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n49 A\<24\> n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U86 (n91 n90 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (B\<22\> n46 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (n101 n100 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (A\<22\> n3 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U93 (n99 n98 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (B\<20\> n43 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (n108 n109 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (A\<20\> n5 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U100 (n106 n107 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (B\<18\> n40 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (n117 n116 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (A\<18\> n39 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U107 (n115 n114 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (B\<16\> n36 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n124 n125 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (A\<16\> n4 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U114 (n122 n123 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (B\<14\> n33 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (n133 n132 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (A\<14\> n32 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U121 (n131 n130 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (B\<12\> n29 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (n141 n140 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (A\<12\> n7 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U128 (n139 n138 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (B\<10\> n26 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (n149 n148 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (A\<9\> n25 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U135 (n146 n147 n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (B\<8\> n24 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (n157 n156 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (A\<8\> n23 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U142 (n155 n154 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (B\<6\> n20 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (n165 n164 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (A\<6\> n19 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U149 (n162 n163 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (B\<4\> n16 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (n173 n172 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (A\<4\> n15 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U156 (n170 n171 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (B\<2\> n13 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n181 n180 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n8 A\<2\> n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U163 (n178 n179 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U168 (A\<1\> n184 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U171 (n6 B\<0\> n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n64 n65 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U64 (A\<31\> n61 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U66 (A\<30\> n60 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (n66 n11 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (B\<29\> n59 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (n73 n72 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U185 (A\<29\> n58 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U69 (n70 n71 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U77 (B\<27\> n56 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (n81 n80 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U184 (A\<27\> n55 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U76 (n78 n79 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (B\<25\> n52 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (n89 n88 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U83 (n86 n87 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U183 (n1 n51 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (B\<23\> n48 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (n96 n97 n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U182 (A\<23\> n47 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U90 (n94 n95 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U98 (B\<21\> n45 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n105 n104 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U181 (A\<21\> n44 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U97 (n102 n103 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (B\<19\> n42 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (n113 n112 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (A\<19\> n41 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U104 (n110 n111 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (B\<17\> n38 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (n121 n120 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U179 (A\<17\> n37 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U111 (n118 n119 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U119 (B\<15\> n35 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (n129 n128 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U178 (A\<15\> n34 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U118 (n126 n127 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U126 (B\<13\> n31 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U127 (n137 n136 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U177 (A\<13\> n30 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U125 (n135 n134 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U133 (B\<11\> n28 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U134 (n145 n144 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U176 (A\<11\> n27 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U132 (n143 n142 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U141 (n153 n152 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U139 (n151 n150 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U140 (n26 B\<10\> n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U175 (A\<9\> n25 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U147 (B\<7\> n22 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (n161 n160 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U174 (A\<7\> n21 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U146 (n158 n159 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U154 (B\<5\> n18 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U155 (n168 n169 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U173 (A\<5\> n17 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U153 (n166 n167 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U161 (B\<3\> n14 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U162 (n177 n176 n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U172 (A\<3\> n9 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U160 (n175 n174 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U169 (B\<1\> n185 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U170 (A\<1\> n184 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U167 (n182 n12 n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_alu_DW01_cmp2_1_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: alu_DW01_cmp2_0
// View name: schematic
subckt soc_no_opt_16may_alu_DW01_cmp2_0_schematic A\<31\> A\<30\> A\<29\> \
        A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> \
        A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> \
        A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> \
        A\<3\> A\<2\> A\<1\> A\<0\> B\<31\> B\<30\> B\<29\> B\<28\> \
        B\<27\> B\<26\> B\<25\> B\<24\> B\<23\> B\<22\> B\<21\> B\<20\> \
        B\<19\> B\<18\> B\<17\> B\<16\> B\<15\> B\<14\> B\<13\> B\<12\> \
        B\<11\> B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> \
        B\<2\> B\<1\> B\<0\> LEQ TC LT_LE GE_GT inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U11 (n64 n11 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U12 (n68 n12 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (A\<29\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (B\<29\> n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (A\<28\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (B\<28\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (A\<27\> n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (B\<27\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (A\<26\> n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (B\<26\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U53 (A\<25\> n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (B\<25\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U51 (A\<24\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (B\<24\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (A\<23\> n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (B\<23\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (A\<22\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U3 (B\<22\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (A\<21\> n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (B\<21\> n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (A\<20\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (B\<20\> n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (A\<19\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (B\<19\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U5 (A\<18\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U41 (B\<18\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (A\<17\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (B\<17\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (A\<15\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (B\<15\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U35 (A\<14\> n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U8 (B\<14\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (A\<13\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (B\<13\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (A\<12\> n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U31 (B\<12\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (A\<31\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U61 (B\<30\> n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (A\<10\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U27 (B\<9\> n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (A\<7\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (B\<7\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (A\<6\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (B\<6\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (A\<5\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (B\<5\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (A\<4\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (B\<4\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (A\<3\> n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U10 (B\<3\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U15 (A\<2\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U9 (B\<2\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U13 (n184 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (B\<8\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (A\<8\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (A\<16\> n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (B\<16\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (n6 n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (A\<11\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n29 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (B\<11\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (A\<0\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U187 (B\<31\> n62 n63 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U63 (n11 n63 LT_LE inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U69 (n61 A\<30\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U68 (n70 n69 n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U73 (n76 n75 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U74 (B\<28\> n58 n76 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U76 (n4 A\<28\> n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U75 (n78 n77 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U80 (n84 n83 n82 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U81 (B\<26\> n55 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U83 (A\<26\> n54 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U82 (n86 n85 n83 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U87 (n92 n91 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U88 (B\<24\> n51 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U90 (n7 A\<24\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U89 (n94 n93 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U94 (n100 n99 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U95 (B\<22\> n48 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U97 (A\<22\> n3 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U96 (n102 n101 n99 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U101 (n108 n107 n106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U102 (B\<20\> n45 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U104 (A\<20\> n44 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U103 (n110 n109 n107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U108 (n116 n115 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U109 (B\<18\> n5 n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U111 (A\<18\> n41 n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U110 (n118 n117 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U115 (n124 n123 n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U118 (A\<16\> n6 n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U117 (n126 n125 n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U122 (n132 n131 n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U123 (B\<14\> n35 n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U125 (A\<14\> n8 n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U124 (n134 n133 n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U129 (n140 n139 n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U130 (B\<12\> n32 n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U132 (A\<12\> n31 n142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U131 (n142 n141 n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U137 (B\<10\> n28 n148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U138 (n149 n150 n147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U139 (A\<9\> n27 n150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U136 (n147 n148 n146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U151 (B\<6\> n22 n164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U152 (n166 n165 n163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U153 (A\<6\> n21 n166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U150 (n163 n164 n162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U158 (B\<4\> n18 n172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U159 (n174 n173 n171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U160 (n17 A\<4\> n174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U157 (n171 n172 n170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U165 (n15 B\<2\> n180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U166 (n182 n181 n179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U167 (A\<2\> n9 n182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U164 (n179 n180 n178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U169 (n185 A\<1\> n184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U146 (A\<8\> n25 n158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U143 (n155 n156 n154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U144 (B\<8\> n26 n156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U145 (n158 n157 n155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U116 (n1 n38 n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U172 (B\<0\> n14 n185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U64 (n65 n66 n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U65 (B\<31\> n62 n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U67 (A\<30\> n61 n67 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U66 (n67 n12 n65 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (n72 n71 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (B\<29\> n60 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U186 (A\<29\> n59 n73 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (n74 n73 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U77 (n79 n80 n77 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (B\<27\> n57 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U185 (A\<27\> n56 n81 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U79 (n82 n81 n79 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U84 (n87 n88 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (B\<25\> n53 n88 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U184 (A\<25\> n52 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U86 (n90 n89 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (n95 n96 n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U92 (B\<23\> n50 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U183 (A\<23\> n49 n97 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U93 (n98 n97 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U98 (n103 n104 n101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (B\<21\> n47 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U182 (A\<21\> n46 n105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U100 (n106 n105 n103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (n111 n112 n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U106 (B\<19\> n43 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U181 (A\<19\> n42 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U107 (n114 n113 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U112 (n119 n120 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U113 (B\<17\> n40 n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U180 (A\<17\> n39 n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U114 (n121 n122 n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U119 (n127 n128 n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (B\<15\> n37 n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U179 (A\<15\> n36 n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U121 (n130 n129 n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U126 (n135 n136 n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U127 (B\<13\> n34 n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U178 (A\<13\> n33 n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U128 (n138 n137 n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U133 (n143 n144 n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U135 (n146 n145 n143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U177 (n29 A\<11\> n145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U141 (B\<10\> n28 n152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U142 (n154 n153 n151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U176 (A\<9\> n27 n153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U140 (n151 n152 n149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U149 (n162 n161 n159 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U147 (n160 n159 n157 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U148 (B\<7\> n24 n160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U175 (A\<7\> n23 n161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U155 (B\<5\> n20 n168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U156 (n170 n169 n167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U174 (A\<5\> n19 n169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U154 (n168 n167 n165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U162 (B\<3\> n16 n176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U163 (n178 n177 n175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U173 (A\<3\> n10 n177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U161 (n176 n175 n173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U170 (B\<1\> n186 n183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U171 (n185 A\<1\> n186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U168 (n183 n13 n181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U134 (n30 n2 n144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_alu_DW01_cmp2_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: alu_DW01_sub_0
// View name: schematic
subckt soc_no_opt_16may_alu_DW01_sub_0_schematic A\<31\> A\<30\> A\<29\> \
        A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> \
        A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> \
        A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> \
        A\<3\> A\<2\> A\<1\> A\<0\> B\<31\> B\<30\> B\<29\> B\<28\> \
        B\<27\> B\<26\> B\<25\> B\<24\> B\<23\> B\<22\> B\<21\> B\<20\> \
        B\<19\> B\<18\> B\<17\> B\<16\> B\<15\> B\<14\> B\<13\> B\<12\> \
        B\<11\> B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> \
        B\<2\> B\<1\> B\<0\> CI DIFF\<31\> DIFF\<30\> DIFF\<29\> \
        DIFF\<28\> DIFF\<27\> DIFF\<26\> DIFF\<25\> DIFF\<24\> DIFF\<23\> \
        DIFF\<22\> DIFF\<21\> DIFF\<20\> DIFF\<19\> DIFF\<18\> DIFF\<17\> \
        DIFF\<16\> DIFF\<15\> DIFF\<14\> DIFF\<13\> DIFF\<12\> DIFF\<11\> \
        DIFF\<10\> DIFF\<9\> DIFF\<8\> DIFF\<7\> DIFF\<6\> DIFF\<5\> \
        DIFF\<4\> DIFF\<3\> DIFF\<2\> DIFF\<1\> DIFF\<0\> CO inh_gnd \
        inh_gnds inh_vdd inh_vdds
    U63 (A\<12\> n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_BUFx1_PB4_AFBB
    U12 (carry\<2\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U13 (carry\<25\> n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U10 (carry\<13\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (carry\<11\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U6 (carry\<21\> n4 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U7 (carry\<18\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U11 (carry\<22\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U8 (carry\<16\> n6 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U2_15 (n132 n33 n3 carry\<16\> DIFF\<15\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_12 (n130 n29 n63 carry\<13\> DIFF\<12\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_24 (n68 n46 n2 carry\<25\> DIFF\<24\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_2 (A\<2\> n118 n10 carry\<3\> DIFF\<2\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_27 (n138 n13 A\<27\> carry\<28\> DIFF\<27\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_26 (n27 n137 A\<26\> carry\<27\> DIFF\<26\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_25 (A\<25\> n136 n11 carry\<26\> DIFF\<25\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_23 (n135 n35 A\<23\> carry\<24\> DIFF\<23\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_20 (n134 n55 A\<20\> carry\<21\> DIFF\<20\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_17 (n25 n133 A\<17\> carry\<18\> DIFF\<17\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_13 (A\<13\> n131 n8 carry\<14\> DIFF\<13\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_11 (A\<11\> n129 n7 carry\<12\> DIFF\<11\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_10 (n128 n44 A\<10\> carry\<11\> DIFF\<10\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_9 (n38 n127 A\<9\> carry\<10\> DIFF\<9\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_8 (n126 n50 A\<8\> carry\<9\> DIFF\<8\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_7 (A\<7\> n59 n125 carry\<8\> DIFF\<7\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_6 (n124 n48 A\<6\> carry\<7\> DIFF\<6\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_5 (A\<5\> n15 n123 carry\<6\> DIFF\<5\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_4 (n122 n17 A\<4\> carry\<5\> DIFF\<4\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_3 (n19 n119 A\<3\> carry\<4\> DIFF\<3\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_21 (A\<21\> n67 n4 carry\<22\> DIFF\<21\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_14 (n66 n21 A\<14\> carry\<15\> DIFF\<14\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_18 (n64 A\<18\> n5 carry\<19\> DIFF\<18\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_31 (A\<31\> n141 carry\<31\> NeTt_565 DIFF\<31\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_1 (A\<1\> carry\<1\> n121 carry\<2\> DIFF\<1\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U2_22 (n39 n53 n9 carry\<23\> DIFF\<22\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_19 (n40 n31 A\<19\> carry\<20\> DIFF\<19\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_28 (n41 n23 A\<28\> carry\<29\> DIFF\<28\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U2_16 (n61 n42 n6 carry\<17\> DIFF\<16\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U138 (B\<15\> n132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n32 n33 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (carry\<15\> n32 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n36 n3 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (A\<15\> n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U136 (B\<12\> n130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n28 n29 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (carry\<12\> n28 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U112 (n111 n103 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U118 (n114 n107 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U114 (n112 n105 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U94 (n92 DIFF\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U116 (n113 n106 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U110 (n110 n101 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U108 (n109 n99 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U88 (n88 n81 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U92 (n90 n83 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U86 (n87 n79 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U84 (n86 n77 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U90 (n89 n82 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U82 (n85 n75 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U70 (n70 DIFF\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U106 (n108 n97 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U93 (n91 carry\<31\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U68 (B\<24\> n68 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n45 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U46 (carry\<24\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U3 (n62 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (A\<24\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U124 (B\<2\> n118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U144 (B\<27\> n138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U15 (n12 n13 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U14 (carry\<27\> n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U143 (B\<26\> n137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U29 (n26 n27 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (carry\<26\> n26 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U142 (B\<25\> n136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U141 (B\<23\> n135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U37 (n34 n35 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (carry\<23\> n34 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U140 (B\<20\> n134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U56 (n54 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (carry\<20\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U139 (B\<17\> n133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n24 n25 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U26 (carry\<17\> n24 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U137 (B\<13\> n131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U135 (B\<11\> n129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U134 (B\<10\> n128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U45 (n43 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (carry\<10\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U133 (B\<9\> n127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U39 (n37 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (carry\<9\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U132 (B\<8\> n126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U51 (n49 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (carry\<8\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U131 (B\<7\> n125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U60 (n58 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U59 (carry\<7\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U130 (B\<6\> n124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U49 (n47 n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U48 (carry\<6\> n47 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U129 (B\<5\> n123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U17 (n14 n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (carry\<5\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U128 (B\<4\> n122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U19 (n16 n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (carry\<4\> n16 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U125 (B\<3\> n119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U21 (n18 n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (carry\<3\> n18 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U65 (A\<0\> n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U80 (n84 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (B\<21\> n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (B\<14\> n66 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U23 (n20 n21 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (carry\<14\> n20 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U64 (B\<18\> n64 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U147 (B\<31\> n141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U127 (B\<1\> n121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U119 (n115 carry\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U61 (A\<16\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (n60 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U146 (B\<30\> n140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U145 (B\<29\> n139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U126 (B\<0\> n120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U96 (A\<30\> n94 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U69 (n69 carry\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U52 (n139 n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (A\<29\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (n56 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U57 (carry\<29\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U95 (carry\<30\> n93 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U53 (A\<22\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (n52 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (B\<22\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U33 (n30 n31 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U32 (carry\<19\> n30 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U41 (B\<19\> n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U25 (n22 n23 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (carry\<28\> n22 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U42 (B\<28\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (B\<16\> n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U111 (A\<30\> n140 n111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U102 (n69 n103 n102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U103 (B\<30\> n105 n104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U117 (n102 n104 n114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U104 (n107 n106 n92 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U109 (carry\<30\> n140 n110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U101 (n94 n101 n100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U100 (B\<30\> n99 n98 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U107 (A\<30\> carry\<30\> n109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U115 (n100 n98 n113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U77 (n51 n81 n80 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U76 (n56 n79 n78 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U85 (A\<29\> n139 n87 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U91 (n80 n78 n90 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U83 (n139 n57 n86 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U75 (n1 n77 n76 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U74 (B\<29\> n75 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U81 (A\<29\> n57 n85 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U89 (n76 n74 n89 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U78 (n82 n83 n70 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U98 (B\<30\> n94 n96 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U105 (n95 n112 n108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U97 (B\<30\> n93 n95 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U99 (n96 n97 n91 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U121 (A\<0\> B\<0\> n116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U123 (n116 n117 DIFF\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U122 (n120 n65 n117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U79 (n71 n88 n84 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U71 (n56 n51 n71 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U73 (n72 n73 n69 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U72 (B\<29\> n1 n72 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U120 (A\<0\> n120 n115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U87 (n56 n1 n88 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_NOR2x1_PB4_AFBB
    U113 (n94 n93 n112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
ends soc_no_opt_16may_alu_DW01_sub_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: alu_DW01_add_0
// View name: schematic
subckt soc_no_opt_16may_alu_DW01_add_0_schematic A\<31\> A\<30\> A\<29\> \
        A\<28\> A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> \
        A\<20\> A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> \
        A\<12\> A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> \
        A\<3\> A\<2\> A\<1\> A\<0\> B\<31\> B\<30\> B\<29\> B\<28\> \
        B\<27\> B\<26\> B\<25\> B\<24\> B\<23\> B\<22\> B\<21\> B\<20\> \
        B\<19\> B\<18\> B\<17\> B\<16\> B\<15\> B\<14\> B\<13\> B\<12\> \
        B\<11\> B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> \
        B\<2\> B\<1\> B\<0\> CI SUM\<31\> SUM\<30\> SUM\<29\> SUM\<28\> \
        SUM\<27\> SUM\<26\> SUM\<25\> SUM\<24\> SUM\<23\> SUM\<22\> \
        SUM\<21\> SUM\<20\> SUM\<19\> SUM\<18\> SUM\<17\> SUM\<16\> \
        SUM\<15\> SUM\<14\> SUM\<13\> SUM\<12\> SUM\<11\> SUM\<10\> \
        SUM\<9\> SUM\<8\> SUM\<7\> SUM\<6\> SUM\<5\> SUM\<4\> SUM\<3\> \
        SUM\<2\> SUM\<1\> SUM\<0\> CO inh_gnd inh_gnds inh_vdd inh_vdds
    U48 (B\<17\> n51 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U49 (n51 n47 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U43 (n41 n42 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U42 (carry\<17\> n41 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U5 (n48 n4 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U4 (A\<17\> n48 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U76 (n74 n73 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U77 (n75 n72 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U68 (carry\<6\> n68 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U69 (n68 n69 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U67 (n66 n67 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U55 (n54 n55 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U54 (B\<7\> n54 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U66 (carry\<7\> n66 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U64 (carry\<9\> n64 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U65 (n64 n65 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U62 (carry\<24\> n62 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U63 (n62 n63 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U60 (carry\<8\> n60 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U61 (n60 n61 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U58 (carry\<10\> n58 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U59 (n58 n59 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U56 (carry\<18\> n56 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U57 (n56 n57 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U52 (carry\<28\> n52 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U53 (n52 n53 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U50 (carry\<14\> n49 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U51 (n49 n50 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U47 (n45 n46 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U37 (n35 n36 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U36 (carry\<30\> n35 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U46 (B\<30\> n45 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U44 (A\<21\> n43 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U45 (n43 n44 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U40 (carry\<3\> n39 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U41 (n39 n40 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U39 (n37 n38 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U19 (n17 n18 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U18 (B\<12\> n17 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U38 (carry\<12\> n37 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U35 (n33 n34 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U17 (n15 n16 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U16 (B\<26\> n15 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U34 (carry\<26\> n33 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U32 (carry\<5\> n31 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U33 (n31 n32 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U30 (carry\<27\> n29 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U31 (n29 n30 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U29 (n27 n28 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U21 (n19 n20 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U20 (B\<23\> n19 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U28 (carry\<23\> n27 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U26 (carry\<4\> n25 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U27 (n25 n26 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U24 (carry\<22\> n23 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U25 (n23 n24 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U22 (carry\<15\> n21 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U23 (n21 n22 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U7 (n5 n6 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U2 (n1 n2 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U1 (A\<13\> n1 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U6 (carry\<13\> n5 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_invx2_PB4_AFBB
    U72 (B\<0\> n71 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U71 (A\<0\> n70 inh_gnd inh_gnds inh_vdd inh_vdds) LVT_invx2_PB4_AFBB
    U74 (A\<0\> n71 n74 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U75 (B\<0\> n70 n75 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U70 (n71 n70 carry\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1_17 (n42 n47 n4 carry\<18\> SUM\<17\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_6 (A\<6\> n69 B\<6\> carry\<7\> SUM\<6\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_7 (A\<7\> n67 n55 carry\<8\> SUM\<7\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_9 (A\<9\> n65 B\<9\> carry\<10\> SUM\<9\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_24 (B\<24\> n63 A\<24\> carry\<25\> SUM\<24\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_8 (B\<8\> n61 A\<8\> carry\<9\> SUM\<8\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_10 (B\<10\> n59 A\<10\> carry\<11\> SUM\<10\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_18 (B\<18\> n57 A\<18\> carry\<19\> SUM\<18\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_28 (B\<28\> n53 A\<28\> carry\<29\> SUM\<28\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_14 (B\<14\> n50 A\<14\> carry\<15\> SUM\<14\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_30 (n36 n46 A\<30\> carry\<31\> SUM\<30\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_21 (B\<21\> n44 n14 carry\<22\> SUM\<21\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_3 (A\<3\> n40 B\<3\> carry\<4\> SUM\<3\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_12 (n38 n18 A\<12\> carry\<13\> SUM\<12\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_26 (n16 n34 A\<26\> carry\<27\> SUM\<26\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_5 (A\<5\> n32 B\<5\> carry\<6\> SUM\<5\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_27 (B\<27\> n30 A\<27\> carry\<28\> SUM\<27\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_23 (n20 n28 A\<23\> carry\<24\> SUM\<23\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_4 (B\<4\> n26 A\<4\> carry\<5\> SUM\<4\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_22 (B\<22\> n24 A\<22\> carry\<23\> SUM\<22\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_15 (A\<15\> n22 B\<15\> carry\<16\> SUM\<15\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_13 (n2 n6 B\<13\> carry\<14\> SUM\<13\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_2 (A\<2\> B\<2\> n10 carry\<3\> SUM\<2\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_11 (A\<11\> B\<11\> n13 carry\<12\> SUM\<11\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_29 (B\<29\> A\<29\> n12 carry\<30\> SUM\<29\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_25 (B\<25\> A\<25\> n11 carry\<26\> SUM\<25\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_20 (A\<20\> B\<20\> n9 carry\<21\> SUM\<20\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_16 (A\<16\> B\<16\> n8 carry\<17\> SUM\<16\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_31 (A\<31\> B\<31\> n7 NeTt_395 SUM\<31\> inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_FAx1_PB4_AFBB
    U1_19 (B\<19\> A\<19\> n3 carry\<20\> SUM\<19\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U1_1 (B\<1\> A\<1\> carry\<1\> carry\<2\> SUM\<1\> inh_gnd inh_gnds \
        inh_vdd inh_vdds) LVT_FAx1_PB4_AFBB
    U15 (carry\<21\> n14 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U11 (carry\<2\> n10 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U14 (carry\<11\> n13 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U13 (carry\<29\> n12 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U12 (carry\<25\> n11 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U10 (carry\<20\> n9 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U9 (carry\<16\> n8 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U8 (carry\<31\> n7 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U3 (carry\<19\> n3 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_BUFx1_PB4_AFBB
    U73 (n72 n73 SUM\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
ends soc_no_opt_16may_alu_DW01_add_0_schematic
// End of subcircuit definition.

// Library name: soc_no_opt_16may
// Cell name: alu
// View name: schematic
subckt soc_no_opt_16may_alu_schematic A\<31\> A\<30\> A\<29\> A\<28\> \
        A\<27\> A\<26\> A\<25\> A\<24\> A\<23\> A\<22\> A\<21\> A\<20\> \
        A\<19\> A\<18\> A\<17\> A\<16\> A\<15\> A\<14\> A\<13\> A\<12\> \
        A\<11\> A\<10\> A\<9\> A\<8\> A\<7\> A\<6\> A\<5\> A\<4\> A\<3\> \
        A\<2\> A\<1\> A\<0\> B\<31\> B\<30\> B\<29\> B\<28\> B\<27\> \
        B\<26\> B\<25\> B\<24\> B\<23\> B\<22\> B\<21\> B\<20\> B\<19\> \
        B\<18\> B\<17\> B\<16\> B\<15\> B\<14\> B\<13\> B\<12\> B\<11\> \
        B\<10\> B\<9\> B\<8\> B\<7\> B\<6\> B\<5\> B\<4\> B\<3\> B\<2\> \
        B\<1\> B\<0\> operation\<3\> operation\<2\> operation\<1\> \
        operation\<0\> result\<31\> result\<30\> result\<29\> result\<28\> \
        result\<27\> result\<26\> result\<25\> result\<24\> result\<23\> \
        result\<22\> result\<21\> result\<20\> result\<19\> result\<18\> \
        result\<17\> result\<16\> result\<15\> result\<14\> result\<13\> \
        result\<12\> result\<11\> result\<10\> result\<9\> result\<8\> \
        result\<7\> result\<6\> result\<5\> result\<4\> result\<3\> \
        result\<2\> result\<1\> result\<0\> inh_gnd inh_gnds inh_vdd \
        inh_vdds
    U464 (n66 n1669 n514 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U450 (n498 n499 result\<2\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U462 (n60 n513 n511 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U471 (n522 n1609 n519 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U472 (n523 n524 n522 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U470 (n521 n1649 n520 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U586 (n445 n1649 n654 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U469 (n519 n520 n515 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U477 (n531 n530 n529 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U478 (n107 n400 n531 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U481 (n1734 n127 n532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U480 (n174 n1747 n533 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U479 (n532 n533 n528 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U468 (add_res\<2\> n1874 n517 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U467 (sub_res\<2\> n155 n518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U585 (sub_res\<27\> n155 n655 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U466 (n517 n518 n516 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U455 (n504 n1582 n501 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U456 (n505 n506 n504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U457 (n1629 n1688 n506 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U453 (n1629 n503 n502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U452 (n501 n502 n500 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U574 (n1870 n1759 n641 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U573 (n641 n642 n640 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U568 (n58 n1672 n634 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U567 (n634 n633 n632 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U581 (n650 n651 n649 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U591 (n1712 n664 n663 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U565 (n1769 n630 result\<27\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U594 (n444 n1666 n665 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U593 (n667 n1632 n666 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U592 (n665 n666 n662 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U584 (n655 n654 n652 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U583 (add_res\<27\> n1874 n653 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U577 (n646 n75 n645 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U576 (n644 n645 n631 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1580 (n1556 n1495 n1555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1482 (N19 operation\<0\> n1502 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1481 (N18 n1876 n1503 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1479 (operation\<1\> n1501 n1499 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1480 (n1502 n1503 n1501 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1478 (n181 n1620 n1500 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1484 (n60 n1141 n1504 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1457 (n1480 n1481 result\<0\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1579 (add_res\<0\> n1874 n1554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1575 (sub_res\<0\> n155 n1527 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1524 (n1529 n1609 n1528 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1525 (n1530 n1531 n1529 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1523 (n1527 n1528 n1526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1544 (n1748 n107 n1542 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U878 (n1733 n1748 n979 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1542 (n1542 n1639 n1538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1540 (A\<2\> n127 n1541 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1541 (n400 n1721 n1540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1539 (n1540 n1541 n1539 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1465 (n1489 A\<0\> n1483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1466 (n1490 n1491 n1489 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1467 (n1616 n1688 n1491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1460 (n1485 n1727 n1484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1459 (n1483 n1484 n1482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1464 (n50 n1759 n1486 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1461 (n1486 n642 n1485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1355 (n1409 n1410 n389 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1246 (n1334 n1335 n1125 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1452 (n1477 n530 n521 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1453 (n1629 n1751 n530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1183 (n1285 n1286 n906 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1445 (n1472 n1473 n865 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U876 (n1629 n400 n977 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U875 (n977 n976 n975 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U879 (n107 n127 n978 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U877 (n978 n979 n974 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U989 (n1855 n1759 n1099 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U986 (n1013 n905 n1097 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U958 (n1777 n1071 result\<17\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U985 (n1097 n1096 n1072 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U992 (add_res\<17\> n1874 n1104 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U798 (add_res\<21\> n1874 n892 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U990 (n1101 n1102 n1100 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U994 (sub_res\<17\> n155 n1106 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U800 (sub_res\<21\> n155 n894 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U995 (n583 n1649 n1105 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U801 (n584 n1649 n893 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U993 (n1106 n1105 n1103 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U961 (n1075 B\<17\> n1074 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U962 (n1076 n1077 n1075 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U963 (A\<17\> n1688 n1077 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U960 (n1830 n1074 n1073 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U975 (n957 n1687 n1080 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U789 (n1687 n320 n883 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U967 (n1712 n961 n1081 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U966 (n1080 n1081 n1079 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U810 (n615 n906 n903 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U809 (n905 n1634 n904 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U808 (n903 n904 n338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U812 (n583 n1666 n908 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U811 (n907 n908 n901 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U813 (n909 n1672 n907 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U799 (n893 n894 n891 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U796 (n889 n890 n888 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U775 (n1773 n869 result\<21\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U795 (n1861 n1759 n887 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U788 (n883 n882 n870 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U779 (n1860 n874 n872 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U783 (n1588 n1759 n879 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U782 (n879 n642 n878 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1180 (n1281 n1282 n568 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1475 (n1593 n1495 n629 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1196 (n1294 n1293 n909 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1578 (n1876 n1622 n1552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1471 (n1876 n1492 n195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1577 (n181 n1875 n1553 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1573 (operation\<0\> n1875 n1488 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U724 (n260 n718 n817 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U717 (n811 n812 n789 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U730 (B\<23\> n824 n823 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U735 (n828 n1716 n822 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U729 (n823 n822 n821 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U732 (A\<23\> n1688 n826 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U731 (n825 n826 n824 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U720 (n816 n1591 n815 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U722 (n1659 n262 n814 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U719 (n814 n815 n813 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1392 (n1438 n78 n1437 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U219 (n1793 n1844 n232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U218 (n232 n203 n223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1388 (n1437 n203 n1417 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1362 (n1415 n1416 result\<10\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1399 (n1445 n1609 n1444 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1400 (n1446 n1447 n1445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1401 (n119 n513 n1447 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1435 (n1684 n704 n1443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1398 (n1443 n1444 n1439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1397 (add_res\<10\> n1874 n1441 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U713 (add_res\<23\> n1874 n807 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1396 (sub_res\<10\> n155 n1442 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U712 (sub_res\<23\> n155 n808 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1395 (n1441 n1442 n1440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1383 (n1433 B\<10\> n1419 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1365 (n1844 n66 n1420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1364 (n1419 n1420 n1418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1385 (n78 n1688 n1435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1384 (n1434 n1435 n1433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U711 (n807 n808 n806 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U705 (n444 n1649 n799 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U697 (n791 n792 n790 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U701 (n1632 n279 n794 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U700 (n58 n1666 n795 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U699 (n794 n795 n793 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1382 (n1668 n1766 n512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1570 (n1622 n1551 n454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1468 (operation\<1\> n1492 n643 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1462 (n1622 n1487 n642 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1572 (n1492 n1593 n592 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U385 (n421 n420 n416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U407 (n1871 n1759 n452 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U408 (n180 n1688 n451 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U409 (n1648 n453 n449 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U410 (n455 n1677 n453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U406 (n451 n452 n450 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U387 (n424 n423 n422 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U388 (n1731 n425 n424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U386 (n1703 n422 n421 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U587 (n656 n657 n445 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U401 (n1693 n444 n439 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U400 (n58 n1665 n440 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U399 (n439 n440 n438 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U706 (n800 n801 n444 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U395 (n434 n1840 n430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U396 (n1748 n1737 n434 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U394 (n1740 n400 n432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U393 (n1623 n127 n433 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U392 (n432 n433 n431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U384 (add_res\<31\> n1874 n418 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U383 (sub_res\<31\> n155 n419 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U382 (n419 n418 n417 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U715 (n810 n55 n809 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U714 (n809 n598 n730 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U612 (n1849 n117 n688 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U602 (n678 n679 n671 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U603 (n680 n1558 n679 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U605 (n1680 n1688 n682 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U604 (n681 n682 n680 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1215 (n1655 n1688 n1307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1213 (n1305 n1565 n1304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1214 (n1306 n1307 n1305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1218 (n1695 n607 n1303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1212 (n1304 n1303 n1302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1210 (n1299 n1300 result\<12\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1569 (n1601 n21 n234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U821 (n921 n642 n920 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U822 (n1670 n1759 n921 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U816 (n915 n914 n913 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U817 (n1630 n1716 n915 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U825 (n922 n923 n912 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U826 (n924 n1671 n923 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U840 (n940 n939 n927 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U841 (n1712 n360 n940 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U917 (n1712 n375 n1029 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U814 (n910 n911 result\<20\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U833 (add_res\<20\> n1874 n929 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U909 (add_res\<19\> n1874 n1018 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U832 (n1781 n929 n928 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U835 (sub_res\<20\> n155 n932 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U836 (n628 n1649 n931 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U834 (n931 n932 n930 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1389 (n1765 n1709 n203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U744 (n840 n642 n839 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U745 (n1865 n1759 n840 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U757 (n1759 n1864 n848 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U750 (n844 n843 n831 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U751 (n1687 n290 n844 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U899 (n1687 n374 n1002 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U893 (n1857 n1002 n1000 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U906 (n1858 n163 n1015 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U897 (n1859 n1759 n1007 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U903 (n1013 n389 n1012 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U902 (n1011 n1012 n998 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U896 (n1007 n642 n1006 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U889 (n996 n997 result\<19\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1036 (n1684 n1752 n868 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U916 (n1029 n1028 n1016 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U908 (n1782 n1018 n1017 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1568 (n60 n1849 n767 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1259 (n1348 n1349 n785 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1241 (n1331 n1330 n611 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1242 (n1765 n926 n1331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1254 (n1344 n1343 n1342 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U447 (n35 n497 n494 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U446 (n496 n441 n495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U445 (n494 n495 n493 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U442 (n405 A\<28\> n489 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U441 (n404 A\<27\> n490 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U440 (n489 n490 n485 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U438 (n1739 n400 n488 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U439 (n1677 n1740 n487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U437 (n487 n488 n486 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U433 (B\<4\> n481 n480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U431 (n1703 n478 n477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U430 (n476 n477 n472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U449 (sub_res\<30\> n155 n476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U526 (sub_res\<29\> n155 n563 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U432 (n480 n479 n478 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U414 (n458 n459 result\<30\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U488 (n543 n544 result\<29\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U428 (n474 n475 n473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U502 (n560 n474 n559 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U429 (add_res\<30\> n1874 n475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U503 (add_res\<29\> n1874 n560 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U508 (n1703 n565 n564 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U507 (n563 n564 n558 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1240 (n1617 n611 n1319 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1230 (n1319 n1320 n1315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1232 (n1322 n1323 n1321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1233 (n1596 n944 n1323 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1105 (n1606 n481 n1211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1095 (n1211 n1212 n1207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1096 (n1213 n1609 n1212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1231 (n1321 n1609 n1320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1106 (n1223 n1224 n481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1098 (n1763 n846 n1215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1097 (n1214 n1215 n1213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U546 (n1703 n608 n604 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U547 (n610 n609 n608 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U548 (n1669 n611 n610 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1312 (n1387 n1388 n1173 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1156 (n1269 n1270 n722 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1489 (n1509 n1510 n1327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U651 (n738 n737 n736 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1014 (n1129 n642 n1128 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1015 (n1854 n163 n1129 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1023 (n1853 n163 n1134 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1017 (n1130 n1131 n1119 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1018 (n1013 n1132 n1131 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1244 (n1132 n38 n1333 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1245 (n1125 n1641 n1332 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U830 (n926 n1766 n352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1243 (n1332 n1333 n926 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1006 (n1122 n1121 n1120 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1007 (n1630 n1672 n1122 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1004 (n1117 n1118 result\<16\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1028 (n1140 n1139 n1135 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1029 (n1609 n1141 n1140 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1485 (n1506 n1505 n1141 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1486 (n1765 n235 n1506 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1027 (add_res\<16\> n1874 n1137 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1026 (sub_res\<16\> n155 n1138 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1025 (n1137 n1138 n1136 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U371 (n1751 n107 n398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U370 (n1733 n400 n399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U554 (A\<27\> n400 n619 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U369 (n398 n399 n397 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U374 (A\<5\> n127 n402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U558 (n1680 n127 n620 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U373 (n1715 n1748 n403 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U557 (A\<25\> n1748 n621 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U372 (n402 n403 n396 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U556 (n620 n621 n616 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U555 (n1736 n1677 n618 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U553 (n618 n619 n617 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U563 (n35 n628 n625 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U562 (n441 n627 n626 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U561 (n625 n626 n624 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U364 (n391 n392 n390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U363 (n390 n1609 n387 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U361 (n387 n388 n383 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U362 (n389 n1649 n388 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U344 (n368 n369 result\<3\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U349 (n376 n377 n370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U350 (n378 n107 n377 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U360 (add_res\<3\> n1874 n385 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U359 (sub_res\<3\> n155 n386 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U358 (n385 n386 n384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1047 (n1161 A\<15\> n1160 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1046 (n1160 n598 n1152 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1053 (n1166 n1167 n1162 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1054 (n1168 n1609 n1167 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1037 (n1150 n1151 result\<15\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1064 (n1177 n1178 n425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1063 (n1617 n425 n1166 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1070 (n1185 n1184 n1183 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1337 (n1610 n828 n1400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1335 (n219 n667 n1378 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1298 (n1378 n1379 n1374 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1336 (n1399 n1400 n667 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1300 (n1382 n1381 n1380 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1299 (n1380 n1609 n1379 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1288 (n1727 A\<30\> n1370 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1286 (n1370 n1371 n1244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1287 (n1623 n1726 n1371 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1338 (n1401 n1402 n828 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U354 (n107 n1688 n381 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1438 (n1466 n1467 n1236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1557 (n1549 n1550 n1548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U882 (n983 n984 n982 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U484 (n537 n538 n536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1548 (n1546 n1547 n1545 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1347 (n1405 n1406 n798 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U377 (n409 n410 n408 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1112 (n1230 n1231 n1229 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1421 (n1458 n1459 n1457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U886 (n991 n990 n989 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1529 (n1535 n1536 n1534 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1321 (n1393 n1394 n1392 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1203 (n1296 n1297 n747 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U656 (n745 n746 n220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U657 (n615 n747 n746 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U322 (n1733 n1688 n347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U420 (n46 n1688 n467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U268 (n157 n1688 n288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1499 (n1515 n1516 n1198 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1501 (n1705 n1742 n1515 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1500 (n46 n1726 n1516 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U418 (n465 B\<30\> n462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U419 (n466 n467 n465 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U417 (n1659 n464 n463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U416 (n462 n463 n461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U424 (n471 n1740 n470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U426 (n455 n1837 n469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U753 (n1837 n1693 n845 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U423 (n469 n470 n460 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U266 (n286 B\<6\> n285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U265 (n285 n284 n283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U271 (n132 n290 n284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U267 (n287 n288 n286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U752 (n845 n841 n290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U263 (n280 n281 result\<6\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U280 (n300 n301 n296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U289 (n1617 n309 n300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U282 (n303 n304 n302 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U281 (n302 n1609 n301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1428 (n1462 n1463 n1461 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U996 (n1107 n1108 n583 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1328 (n1397 n1398 n1396 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1172 (n1279 n1280 n1092 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1165 (n1276 n1277 n1275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1032 (n1144 n1145 n627 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U950 (n1061 n1062 n496 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U518 (n1680 n404 n577 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1304 (n1386 n1385 n1176 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U913 (n1022 n1023 n442 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1372 (n1427 n1428 n1219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1498 (n1728 n1198 n1514 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1497 (n1514 n1513 n591 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1284 (n1369 n1368 n1034 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1285 (n1728 n1244 n1369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U910 (n1020 n1021 n1019 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U911 (sub_res\<19\> n155 n1021 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U912 (n58 n1649 n1020 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1404 (n1450 n1451 n1222 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1515 (n1524 n1525 n1326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U837 (n933 n934 n628 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U620 (n699 n698 n697 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1148 (n1836 n1265 n1093 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U687 (n777 n778 n776 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1154 (A\<22\> n400 n1267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1153 (n1677 A\<21\> n1268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1152 (n1267 n1268 n1266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U802 (n895 n896 n584 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1412 (n1452 n1453 n1218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U764 (n855 n856 n497 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1507 (n1522 n1523 n1521 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1055 (n1170 n1169 n1168 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1056 (B\<3\> n262 n1170 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U255 (n273 n274 n272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U254 (n272 n1609 n271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1302 (n1383 n1384 n1031 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1058 (n1173 n1762 n1172 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1303 (n1762 n1176 n1384 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1311 (n1708 n1173 n1383 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1059 (n1582 n1034 n1171 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1057 (n1171 n1172 n262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1144 (n1262 n1261 n1260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1145 (n119 n885 n1262 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1142 (n1258 n1259 n1254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1179 (n1684 n568 n1258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U510 (n71 n568 n567 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U509 (n567 n566 n565 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1143 (n1260 n1609 n1259 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1139 (n1256 n1257 n1255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1141 (add_res\<13\> n1874 n1256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U648 (add_res\<25\> n1874 n732 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U646 (n732 n733 n731 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U624 (n1771 n705 result\<25\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1116 (n1237 n1238 result\<13\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1140 (sub_res\<13\> n155 n1257 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U647 (sub_res\<25\> n155 n733 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1135 (n1252 n203 n1251 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1136 (n1253 A\<13\> n1252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1131 (n557 n1842 n1249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1130 (n1846 n1249 n1239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1125 (B\<13\> n1245 n1241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1119 (n1845 n549 n1242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1118 (n1241 n1242 n1240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1127 (A\<13\> n1688 n1247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1126 (n1247 n1246 n1245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U644 (n728 n729 n727 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U661 (n584 n1666 n743 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U655 (n220 n1632 n744 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U207 (n1684 n220 n211 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U654 (n743 n744 n734 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U635 (n717 n716 n706 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U633 (n1646 n1759 n715 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U643 (n1759 n1867 n726 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U551 (n1700 n1730 n429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1496 (n62 n1708 n1507 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U845 (n1693 n62 n943 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1487 (n1507 n1508 n235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1236 (n1708 n1327 n1324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1235 (n1326 n1641 n1325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1488 (n1327 n1641 n1508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U846 (n944 n1767 n942 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1234 (n1324 n1325 n944 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U844 (n942 n943 n349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1011 (n1665 n1606 n637 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1008 (n1606 n1693 n677 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U626 (n709 n708 n707 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U523 (n583 n1665 n582 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U522 (n581 n582 n580 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U524 (n35 n584 n581 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U627 (n583 n1672 n709 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1380 (n1432 n1708 n1086 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U919 (n1031 n1766 n1009 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1301 (n30 n1031 n1382 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U337 (n362 n363 n361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U770 (n521 n1752 n864 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U771 (n1699 n865 n863 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U768 (n1632 n309 n862 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U769 (n863 n864 n309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U737 (n829 n830 result\<22\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U767 (n862 n861 n849 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U760 (add_res\<22\> n1874 n851 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U759 (n1780 n851 n850 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U762 (sub_res\<22\> n155 n854 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U763 (n497 n1649 n853 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U761 (n853 n854 n852 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U741 (n1863 n835 n833 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U747 (n295 n55 n835 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U632 (n715 n642 n714 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U348 (n1695 n375 n372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U346 (n372 n373 n371 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U347 (n132 n374 n373 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U900 (n1008 n1009 n374 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U901 (n1763 n1010 n1008 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U918 (n1030 n1009 n375 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U843 (n1665 n177 n941 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U327 (n1822 n1617 n351 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U326 (n350 n351 n341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U328 (n353 A\<4\> n350 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U319 (n344 n343 n342 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U320 (n345 n1731 n344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U321 (n346 n347 n345 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U317 (n339 n340 result\<4\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1367 (n1423 n60 n1422 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U220 (n60 n235 n233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U973 (n1087 n1086 n1084 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U974 (n1838 n1582 n1087 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1369 (n1837 n38 n1425 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1371 (n1219 n1641 n1424 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1101 (n1219 n1708 n1216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1099 (n1216 n1217 n846 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1100 (n1218 n1762 n1217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1411 (n1218 n1708 n1448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1368 (n1424 n1425 n1423 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1403 (n1222 n1762 n1449 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U943 (n513 n1766 n1053 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1402 (n1448 n1449 n513 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1283 (n1034 n1641 n1366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1281 (n1640 n1582 n1367 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1279 (n1766 n1010 n648 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1277 (n1816 n132 n1365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1280 (n1366 n1367 n1010 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1292 (n1373 n19 n1364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1276 (n1364 n1365 n1355 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1273 (n1363 n1310 n664 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1272 (n664 n1695 n1357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U969 (n1083 n1082 n961 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U970 (n1765 n1831 n1083 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U862 (n961 n1695 n958 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1275 (n1700 n1034 n1363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1267 (B\<11\> n1359 n1358 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1268 (n1360 n1361 n1359 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1269 (n1657 n1688 n1361 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1266 (n1358 n1357 n1356 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1264 (n1353 n1354 result\<11\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1297 (add_res\<11\> n1874 n1376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1296 (sub_res\<11\> n155 n1377 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1295 (n1376 n1377 n1375 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U977 (n1089 n1082 n957 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1124 (n1696 n1766 n201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1390 (n1742 n1696 n598 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U938 (n1049 n1050 n1038 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U939 (n1051 n30 n1050 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U980 (n1762 n1092 n1091 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U979 (n1090 n1091 n216 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1155 (n722 n1708 n1263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1146 (n1263 n1264 n885 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1147 (n1093 n1641 n1264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U981 (n38 n1093 n1090 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U978 (n216 n1766 n1082 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U203 (n1763 n216 n215 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1473 (n219 n1699 n696 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U262 (n219 n279 n270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U253 (n270 n271 n266 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U703 (n389 n1634 n797 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U638 (n1624 n1634 n720 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U637 (n719 n720 n197 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U639 (n722 n1699 n719 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U704 (n1700 n798 n796 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U702 (n796 n797 n279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U944 (n1055 n1056 n1054 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U926 (n1775 n1037 result\<18\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1437 (n1610 n1236 n1465 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1225 (n132 n1610 n1314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1436 (n1464 n1465 n704 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U935 (n521 n1013 n1047 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U946 (add_res\<18\> n1874 n1058 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U947 (n1060 n1059 n1057 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U948 (sub_res\<18\> n155 n1060 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U949 (n496 n1649 n1059 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U936 (A\<18\> n1048 n1046 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U929 (n1560 n1041 n1040 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U934 (n1046 n1047 n1045 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U928 (n1795 n1040 n1039 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U931 (n153 n1688 n1043 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U930 (n1042 n1043 n1041 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U869 (n1609 n968 n966 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U868 (n905 n1649 n967 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U867 (n966 n967 n962 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U870 (n969 n970 n968 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U202 (n214 n215 n213 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U201 (n213 n1609 n212 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U200 (n211 n212 n206 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1193 (A\<1\> n1677 n976 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U516 (n1739 n1595 n574 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1192 (A\<0\> n400 n1290 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U515 (n1735 n400 n575 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1191 (n1290 n976 n905 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U517 (n576 n577 n572 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U519 (A\<27\> n127 n576 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1133 (n1742 n127 n1250 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U514 (n574 n575 n573 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U227 (n243 n244 n242 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U226 (n242 n1609 n241 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U243 (n132 n260 n254 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U237 (n255 n254 n253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U238 (n40 n256 n255 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U727 (n262 n1767 n818 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U726 (n1640 n35 n819 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1040 (n1640 n1842 n1155 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1039 (n1154 n1155 n1153 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1041 (B\<15\> n1156 n1154 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U725 (n818 n819 n260 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1043 (A\<15\> n1688 n1158 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1042 (n1158 n1157 n1156 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U247 (n265 n156 n264 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U246 (n264 n203 n263 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U244 (n1848 n261 n252 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U245 (n1845 n262 n261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U235 (n250 n251 result\<7\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U240 (n156 n1688 n258 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U239 (n257 n258 n256 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U250 (n268 n269 n267 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U252 (add_res\<7\> n1874 n268 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U866 (add_res\<1\> n1874 n964 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U864 (n964 n965 n963 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U251 (sub_res\<7\> n155 n269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U865 (sub_res\<1\> n155 n965 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U190 (n131 n197 n189 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U184 (n190 n189 n188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U185 (n191 n1571 n190 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U186 (n192 n193 n191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U187 (n85 n1688 n193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U636 (n718 n197 n717 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U855 (n1721 n1688 n955 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U853 (n953 n1729 n952 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U854 (n954 n955 n953 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U850 (n947 n948 result\<1\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U860 (n960 n1721 n959 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U859 (n958 n959 n949 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U858 (n131 n957 n951 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U852 (n952 n951 n950 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U672 (A\<24\> n1688 n762 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U670 (n760 B\<24\> n759 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U669 (n758 n759 n752 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U671 (n762 n761 n760 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U679 (n235 n117 n768 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1087 (n1842 n1837 n1203 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1370 (n1198 n1563 n1426 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1080 (n1592 n1198 n1196 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1079 (n1196 n1195 n464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1132 (n1088 n1250 n557 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1121 (n1592 n1244 n1243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1120 (n1243 n1195 n549 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1134 (n1244 n1563 n1088 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1222 (n1313 A\<12\> n1312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1221 (n1311 n1312 n1301 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1224 (n62 n1842 n1311 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U498 (n556 n1623 n555 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1122 (A\<31\> n1841 n1195 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1219 (n1309 n1310 n607 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U545 (n607 n55 n605 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U544 (n604 n605 n600 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1274 (n1725 n1742 n1310 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U692 (n1699 n1630 n784 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U691 (n784 n783 n249 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U530 (n455 n62 n590 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U529 (n589 n590 n588 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U532 (n593 B\<28\> n589 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U533 (n594 n595 n593 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U534 (n1735 n1688 n595 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1220 (n1700 n62 n1309 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U541 (n602 n603 n601 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U543 (add_res\<28\> n1874 n602 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1094 (add_res\<14\> n1874 n1209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1092 (n1209 n1210 n1208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U527 (n585 n586 result\<28\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U542 (sub_res\<28\> n155 n603 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1093 (sub_res\<14\> n155 n1210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U537 (n597 n598 n587 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U538 (n599 n1736 n597 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U497 (n554 n555 n545 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U490 (n547 n548 n546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U492 (B\<29\> n550 n547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U500 (n455 n1624 n554 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U790 (n884 n880 n320 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U298 (n131 n320 n314 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U791 (n1624 n35 n884 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U308 (n331 n1609 n330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U336 (n361 n1609 n358 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U309 (n332 n333 n331 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U494 (n1739 n1688 n552 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U493 (n551 n552 n550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U787 (n549 n30 n881 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U786 (n881 n880 n324 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U491 (n1659 n549 n548 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U749 (n1763 n464 n842 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1077 (n1193 n1194 n1192 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1081 (B\<14\> n1199 n1193 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1078 (n1845 n464 n1194 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1083 (A\<14\> n1688 n1201 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1082 (n1201 n1200 n1199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U792 (n885 n117 n880 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U352 (n379 n1765 n376 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U353 (n381 n380 n379 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1075 (n1189 n1190 result\<14\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1086 (n1847 n1203 n1191 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1088 (n1205 n203 n1204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1089 (n1206 n69 n1205 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U335 (n1696 n360 n359 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U842 (n941 n1792 n360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U334 (n358 n359 n354 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U325 (n131 n349 n343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U723 (n1712 n1767 n725 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U754 (n1767 n846 n841 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U748 (n842 n841 n295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U272 (n291 n292 n282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U273 (n293 A\<6\> n292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U275 (n1695 n295 n291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U300 (n323 A\<5\> n322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U302 (n1696 n324 n321 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U299 (n321 n322 n312 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U785 (n324 n55 n874 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U662 (n750 n751 result\<24\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U664 (n755 n754 n753 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U684 (sub_res\<24\> n155 n773 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U683 (n773 n772 n769 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U682 (add_res\<24\> n1874 n771 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U614 (n691 n1584 n690 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U615 (add_res\<26\> n1874 n691 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U681 (n1584 n771 n770 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U598 (n497 n1666 n674 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U597 (n674 n673 n672 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U595 (n669 n670 result\<26\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U665 (n1666 n628 n755 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U616 (n693 n692 n689 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U617 (sub_res\<26\> n155 n693 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U306 (add_res\<5\> n1874 n327 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U304 (n327 n328 n326 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U305 (sub_res\<5\> n155 n328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U307 (n329 n330 n325 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U316 (n338 n1606 n329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U290 (n310 n311 result\<5\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U292 (n315 n314 n313 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U293 (n316 B\<5\> n315 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U295 (n94 n1688 n318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U215 (n1714 n1688 n230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U294 (n317 n318 n316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U225 (n240 n241 n236 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U208 (n221 n222 result\<8\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U234 (n1606 n249 n240 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U224 (add_res\<8\> n1874 n238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U223 (sub_res\<8\> n155 n239 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U222 (n238 n239 n237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U213 (n228 n1615 n225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U214 (n229 n230 n228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U211 (n141 n227 n226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U210 (n225 n226 n224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U194 (n205 n85 n204 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U193 (n204 n203 n199 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U182 (n186 n187 result\<9\> inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U199 (add_res\<9\> n1874 n208 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U198 (sub_res\<9\> n155 n209 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U197 (n208 n209 n207 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1229 (add_res\<12\> n1874 n1317 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1227 (n1317 n1318 n1316 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1228 (sub_res\<12\> n155 n1318 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1052 (add_res\<15\> n1874 n1164 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1050 (n1164 n1165 n1163 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U1051 (sub_res\<15\> n155 n1165 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U333 (add_res\<4\> n1874 n356 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U331 (n356 n357 n355 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U332 (sub_res\<4\> n155 n357 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U279 (add_res\<6\> n1874 n298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U278 (sub_res\<6\> n155 n299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U277 (n298 n299 n297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NADN2x1_PB4_AFBB
    U463 (n514 n1764 n509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U451 (n500 n1800 n499 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U465 (n515 n516 n498 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U461 (n512 n511 n510 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U460 (n509 n510 n508 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U487 (n1798 n1723 n534 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U483 (n1820 n134 n535 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U482 (n534 n535 n523 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U474 (n1697 n1796 n526 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U475 (n527 n113 n525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U476 (n528 n529 n527 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U473 (n525 n526 n524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U575 (n1870 n1754 n639 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U454 (n1582 n1760 n503 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U459 (n1629 n1635 n507 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U458 (n507 n166 n505 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U571 (n638 n1869 n635 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U569 (n636 n635 n633 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U570 (n144 n1719 n636 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U572 (n639 n640 n638 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U566 (n631 n632 n630 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U590 (n662 n1817 n650 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U582 (n652 n1770 n651 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U578 (B\<27\> n1583 n646 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U579 (n647 n89 n644 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U580 (n648 n1686 n647 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1582 (operation\<0\> operation\<1\> n1556 inh_gnd inh_gnds inh_vdd \
        inh_vdds) LVT_NOR2x1_PB4_AFBB
    U506 (n1648 n1873 n562 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U505 (n1764 n1872 n561 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U504 (n561 n1709 n474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1477 (n1500 n1499 n1498 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1483 (n1504 n1730 n1497 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1476 (n1497 n1498 n1496 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1522 (n1526 n1779 n1480 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1458 (n1482 n1783 n1481 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1555 (n1724 n1784 n1543 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1546 (n138 n1789 n1544 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1545 (n1544 n1543 n1530 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1527 (n1697 n47 n1533 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1536 (n1537 n150 n1532 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1538 (n1538 n1539 n1537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1526 (n1533 n1532 n1531 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1543 (n111 n4 n1132 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1470 (n1705 n169 n1494 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1472 (n116 n1651 n1493 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1469 (n1493 n1494 n1490 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1358 (n52 n50 n1411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1357 (n1720 n167 n1412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1356 (n1411 n1412 n1410 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1361 (n1843 n1706 n1413 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1360 (n1707 n29 n1414 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1359 (n1413 n1414 n1409 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1251 (n1706 n29 n1338 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1250 (n1338 n1339 n1334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1249 (n1720 n147 n1336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1186 (n1843 n147 n1287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1248 (n1843 n84 n1337 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1247 (n1336 n1337 n1335 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1455 (n1720 n1744 n1479 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1456 (n126 n4 n1478 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1454 (n1479 n1478 n1477 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1185 (n108 n1690 n1288 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1184 (n1287 n1288 n1286 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1448 (n108 n149 n1474 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1447 (n126 n142 n1475 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1189 (n142 n1744 n1289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1449 (n1476 n542 n1472 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1446 (n1474 n1475 n1473 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1187 (n988 n1289 n1285 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U874 (n974 n975 n973 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U988 (n1099 n1661 n1098 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U987 (n1098 n87 n1096 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U959 (n1072 n1073 n1071 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U991 (n1103 n1778 n1102 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1000 (n868 n1811 n1113 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U999 (n1113 n1823 n1101 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1003 (n1827 n1719 n1115 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1002 (n1825 n1675 n1116 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1001 (n1116 n1115 n1114 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U965 (A\<17\> n179 n1078 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U964 (n1710 n1078 n1076 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U807 (n1631 n1828 n902 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U806 (n901 n902 n889 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U797 (n891 n1774 n890 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U776 (n870 n1824 n869 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U793 (n886 n1709 n882 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U794 (n887 n1862 n886 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U781 (n878 n877 n876 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U780 (n876 n1861 n875 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U784 (n1588 n1689 n877 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U778 (n1825 n63 n873 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U777 (n873 n872 n871 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1195 (n1811 n150 n1292 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1202 (n1825 n133 n1291 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1194 (n1291 n1292 n1281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1190 (n1697 n1835 n1283 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1182 (n151 n1827 n1284 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U660 (n151 n1835 n748 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1181 (n1283 n1284 n1282 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1581 (n1622 operation\<2\> n1495 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1197 (n411 n993 n1294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1200 (n1295 n1278 n1293 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U629 (n1811 n63 n711 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1576 (n1552 n1553 n210 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U696 (n790 n789 n788 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U728 (n821 n820 n811 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U736 (n144 n1674 n820 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U718 (n813 n1812 n812 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U734 (A\<23\> n1756 n827 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U733 (n827 n170 n825 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U721 (B\<23\> n179 n816 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1393 (B\<10\> n179 n1438 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1363 (n1417 n1418 n1416 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1394 (n1439 n1440 n1415 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1427 (n138 n1597 n1455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1420 (n1698 n1798 n1456 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1419 (n1455 n1456 n1446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1387 (A\<10\> n1758 n1436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1386 (n1436 n170 n1434 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U710 (n806 n1585 n791 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U698 (n793 n1834 n792 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1574 (n181 n1621 n1492 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1571 (n1594 n181 n1551 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1463 (operation\<2\> n1594 n1487 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U381 (n416 n417 n415 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U403 (n446 n447 n420 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U412 (n457 n1612 n456 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U413 (n1742 n165 n457 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U411 (n456 n1871 n446 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U405 (n449 n450 n448 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U404 (n448 n65 n447 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U397 (n1731 n436 n426 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U398 (n437 n438 n436 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U402 (n137 n1833 n437 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U389 (n427 n426 n423 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U589 (n660 n661 n656 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U588 (n658 n659 n657 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U708 (n805 n804 n800 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U709 (n1865 n1744 n804 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U707 (n802 n803 n801 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U391 (n430 n431 n428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U390 (n428 n1644 n427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1282 (n171 n1741 n435 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U716 (n117 n1741 n810 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U609 (n1569 n1868 n685 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U610 (n1558 n1663 n686 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U611 (n688 n67 n684 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U608 (n685 n684 n678 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U606 (n683 n1612 n681 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U607 (n1680 n1635 n683 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1217 (n1655 n1635 n1308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1216 (n1308 n1612 n1306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1211 (n1301 n1302 n1300 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1226 (n1315 n1316 n1299 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1556 (B\<2\> n117 n443 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U819 (n918 n1574 n917 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U820 (n919 n920 n918 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U824 (n1686 n1792 n916 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U818 (n917 n916 n914 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U827 (B\<20\> n169 n924 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U536 (A\<28\> n169 n596 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U815 (n912 n913 n911 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U831 (n927 n928 n910 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U849 (n1799 n1674 n945 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U848 (n1797 n143 n946 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U847 (n945 n946 n939 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U829 (n1631 n7 n925 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U828 (n925 n1709 n922 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U746 (n1865 n1689 n838 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U743 (n839 n838 n837 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U823 (n1670 n1689 n919 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U756 (n1865 n848 n847 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U742 (n837 n1864 n836 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U904 (n1014 n89 n1011 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U755 (n847 n89 n843 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U894 (n1004 n1858 n1003 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U895 (n1005 n1006 n1004 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U898 (n95 n1754 n1005 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U891 (n1001 n1000 n999 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U905 (n1015 n1859 n1014 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U890 (n998 n1805 n997 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U907 (n1016 n1017 n996 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U923 (n1036 n1035 n1028 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U924 (n868 n144 n1036 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U925 (n1701 n1673 n1035 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1261 (n173 n51 n1350 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1260 (n1351 n1350 n1349 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1262 (n541 n1352 n1348 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1258 (n1818 n137 n1340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1253 (n1698 n1799 n1341 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1252 (n1340 n1341 n1330 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1257 (n1346 n1347 n1343 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1255 (n539 n1345 n1344 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U448 (n1794 n137 n492 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U444 (n493 n492 n491 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U443 (B\<4\> n491 n482 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U434 (n483 n482 n479 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U436 (n485 n486 n484 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U435 (n484 n1644 n483 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U427 (n473 n472 n458 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U501 (n559 n558 n543 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1239 (n1590 n135 n1328 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1238 (n47 n112 n1329 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1237 (n1328 n1329 n1322 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1111 (n146 n112 n1228 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1107 (n1225 n1226 n1224 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1108 (n151 n1790 n1226 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1115 (n1787 n139 n1227 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1110 (n1227 n1228 n1223 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1109 (n1697 n1619 n1225 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1102 (n1220 n1221 n1214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1103 (n1725 n1796 n1221 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1567 (n1726 n1729 n400 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1317 (n109 n54 n805 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1316 (n741 n805 n1387 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1314 (n118 n84 n659 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1158 (n175 n84 n1272 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1492 (n175 n1746 n1511 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1072 (n1654 n1746 n992 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1315 (n1653 n1679 n1389 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1162 (n1679 n1706 n660 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1160 (n660 n742 n1269 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1313 (n1389 n659 n1388 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1491 (n126 n5 n1512 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1493 (n702 n782 n1509 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1490 (n1511 n1512 n1510 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1159 (n1683 n149 n1271 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1168 (n64 n49 n1024 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1157 (n1272 n1271 n1270 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U653 (n741 n742 n737 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U652 (n739 n1604 n738 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U634 (n1754 n118 n713 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1016 (n49 n1754 n1127 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1012 (n1126 n1853 n1123 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1013 (n1127 n1128 n1126 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1022 (n1134 n1854 n1133 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1021 (n1133 n87 n1130 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1010 (n1718 n1821 n1124 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1009 (n1124 n1123 n1121 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1005 (n1119 n1120 n1118 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1024 (n1135 n1136 n1117 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1035 (n1799 n143 n1142 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1031 (n1797 n1651 n1143 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1030 (n1143 n1142 n1139 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1514 (n133 n1791 n1519 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1506 (n1725 n1590 n1520 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1505 (n1519 n1520 n1505 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1566 (n1744 n86 n1469 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1209 (n1851 n1744 n413 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U694 (n138 n1821 n787 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U693 (n786 n787 n783 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U695 (n151 n1639 n786 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1377 (n1707 n5 n703 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1161 (n1707 n118 n742 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1318 (n1745 n172 n741 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1334 (n1854 n1652 n1111 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U368 (n396 n397 n395 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U367 (n395 n114 n393 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U552 (n616 n617 n614 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U550 (n614 n1645 n613 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U559 (n622 n1669 n612 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U560 (n624 n623 n622 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U564 (n1633 n1801 n623 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U376 (n1633 n1826 n407 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U549 (n613 n612 n609 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1528 (n1641 n117 n441 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U366 (n1697 n1809 n394 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1067 (n1697 n1804 n1179 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U365 (n393 n394 n392 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U380 (n1810 n1723 n406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1320 (n1725 n1810 n1391 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U375 (n406 n407 n391 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U345 (n370 n371 n369 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U357 (n383 n384 n368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1048 (B\<15\> n1583 n1161 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1038 (n1152 n1153 n1151 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U351 (B\<3\> n1583 n378 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1049 (n1162 n1163 n1150 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1068 (n1181 n1182 n1177 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1074 (n138 n1701 n1181 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1069 (n1725 n144 n1182 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1073 (n1187 n1188 n1184 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1071 (n992 n1186 n1185 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1354 (n1724 n1804 n1403 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1345 (n1403 n1404 n1399 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1066 (n1724 n1806 n1180 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1065 (n1179 n1180 n1178 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1327 (n136 n1598 n1390 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1346 (n1806 n136 n1404 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1319 (n1390 n1391 n1381 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1565 (B\<1\> n1727 n401 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1339 (n985 n412 n1402 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1342 (n994 n1395 n1401 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1563 (n1469 n1352 n1549 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1441 (n1469 n1460 n1466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1439 (n1468 n540 n1467 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1564 (n1851 n116 n1352 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1558 (n1232 n1345 n1550 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1559 (n126 n80 n1345 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1198 (n126 n1656 n993 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U378 (n411 n412 n410 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1340 (n1638 n129 n412 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1440 (n1851 n129 n540 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1551 (n1653 n81 n1468 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1199 (n1653 n80 n411 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1341 (n1851 n52 n985 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U883 (n985 n986 n984 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U884 (n987 n988 n983 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1188 (n1676 n23 n988 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1309 (n1676 n95 n1027 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U485 (n539 n540 n538 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1256 (n1638 n52 n539 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1450 (n1850 n109 n542 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1553 (n109 n142 n1339 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1263 (n81 n124 n541 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U486 (n541 n542 n537 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1549 (n1468 n1351 n1547 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1550 (n1850 n128 n1351 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1423 (n1654 n128 n1233 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1554 (n124 n23 n1476 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1552 (n1476 n1339 n1546 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1351 (n987 n414 n1405 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1349 (n125 n23 n1408 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1350 (n142 n64 n1407 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1510 (n1859 n64 n857 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1410 (n1859 n124 n937 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1348 (n1407 n1408 n1406 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1207 (n413 n995 n1296 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U379 (n413 n414 n409 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1205 (n81 n167 n986 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1174 (n95 n167 n898 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1113 (n1232 n1233 n1231 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1114 (n1234 n1235 n1230 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1425 (n1346 n1460 n1458 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1426 (n1656 n124 n1346 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1422 (n1146 n1233 n1459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U315 (n139 n1808 n336 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U888 (n994 n995 n990 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1344 (n77 n123 n994 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1442 (n111 n77 n1460 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U887 (n992 n993 n991 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1534 (n1654 n115 n1347 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1533 (n1234 n1347 n1535 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1530 (n1063 n1147 n1536 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1208 (n1638 n1750 n995 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1343 (n1656 n1750 n1395 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1325 (n1295 n1395 n1393 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1326 (n1654 n123 n1295 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1322 (n1109 n1186 n1394 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1323 (n1678 n1749 n1186 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1206 (n1850 n1685 n1298 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1561 (n1656 n1685 n1232 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1204 (n1298 n986 n1297 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1537 (n1582 n30 n615 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U658 (n748 n749 n745 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U659 (n1827 n139 n749 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1353 (n1850 n124 n987 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1352 (n81 n110 n414 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1535 (n1652 n41 n1234 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1562 (n1726 n1563 n404 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U421 (n468 n1710 n466 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U422 (A\<30\> n1599 n468 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U415 (n460 n461 n459 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U425 (B\<30\> n1756 n471 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U270 (n1715 n1756 n289 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U269 (n289 n166 n287 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U276 (n296 n297 n280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U264 (n282 n283 n281 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U283 (n305 n306 n304 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U284 (n1723 n1597 n306 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U288 (n1798 n134 n307 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U287 (n1820 n114 n308 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U286 (n307 n308 n303 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1432 (n1148 n1235 n1462 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1433 (n1852 n110 n1235 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1429 (n935 n1064 n1463 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1431 (n1653 n1660 n935 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U997 (n1109 n162 n1108 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U998 (n1111 n1112 n1107 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1324 (n1852 n51 n1109 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1333 (n90 n1750 n1188 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1329 (n897 n1025 n1398 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1332 (n1111 n1188 n1397 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U803 (n897 n160 n896 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1175 (n1653 n1642 n802 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1520 (n1707 n1642 n938 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1176 (n1026 n1112 n1279 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1173 (n802 n160 n1280 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1201 (n1676 n1678 n1278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1531 (n125 n25 n1147 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1033 (n1146 n1147 n1145 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1424 (n1678 n147 n1146 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1170 (n1745 n25 n1187 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1166 (n1024 n162 n1277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U914 (n1024 n1025 n1023 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1169 (n1187 n1278 n1276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1034 (n1148 n1149 n1144 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1513 (n1745 n1660 n1065 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U951 (n1063 n1064 n1062 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U952 (n1065 n1066 n1061 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1532 (n90 n148 n1063 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1167 (n90 n1749 n1110 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1512 (n168 n1750 n1149 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1430 (n125 n168 n1064 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1177 (n1676 n1661 n1112 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1330 (n126 n1661 n1025 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1331 (n1856 n148 n897 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1434 (n90 n1706 n1148 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1511 (n1065 n1149 n1522 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1306 (n126 n1862 n803 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1521 (n1862 n1652 n859 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1307 (n1865 n1618 n739 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1308 (n899 n1027 n1385 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1305 (n739 n803 n1386 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1178 (n1856 n1652 n1026 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U915 (n1026 n1027 n1022 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1378 (n1870 n1652 n1431 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1290 (n1870 n109 n661 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U622 (n702 n703 n698 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1376 (n1431 n703 n1427 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1375 (n1653 n1738 n1429 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1504 (n1738 n123 n1517 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1502 (n1517 n1518 n1513 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1503 (n1683 n171 n1518 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1374 (n1683 n1690 n1430 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1517 (n1865 n1690 n780 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1373 (n1430 n1429 n1428 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1291 (n1683 n1706 n1372 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1289 (n1372 n661 n1368 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1409 (n1856 n171 n1066 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1408 (n937 n1066 n1450 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1405 (n779 n858 n1451 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1519 (n859 n938 n1524 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1516 (n700 n780 n1525 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U838 (n935 n936 n934 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U839 (n937 n938 n933 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U621 (n700 n701 n699 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U619 (n1794 n1650 n695 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1150 (n56 n1749 n740 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1151 (n1618 n172 n658 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1149 (n658 n1604 n1265 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U689 (n781 n782 n777 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1494 (n111 n172 n782 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U688 (n779 n780 n778 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U686 (n1801 n1650 n775 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U685 (n775 n774 n772 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1310 (n1670 n123 n899 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1406 (n1670 n128 n858 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1509 (n1856 n129 n936 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1407 (n1653 n1588 n779 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U805 (n1707 n1588 n900 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U804 (n899 n900 n895 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1416 (n781 n860 n1452 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1413 (n1454 n701 n1453 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1415 (n1646 n1618 n1454 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1495 (n1646 n123 n702 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U766 (n859 n860 n855 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1508 (n857 n936 n1523 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U765 (n857 n858 n856 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1560 (n1563 n1616 n405 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1417 (n1865 n115 n860 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1414 (n126 n53 n701 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1518 (n1653 n56 n700 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1418 (n1745 n56 n781 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1062 (n1814 n136 n1174 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1061 (n1725 n1809 n1175 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U257 (n151 n1598 n276 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1060 (n1174 n1175 n1169 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U258 (n1697 n1814 n275 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U256 (n275 n276 n274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U260 (n1725 n1826 n278 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U261 (n1810 n135 n277 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1171 (n1829 n135 n1273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U259 (n277 n278 n273 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1164 (n1725 n145 n1274 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1163 (n1273 n1274 n1261 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1138 (n1254 n1255 n1237 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1117 (n1240 n1239 n1238 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1137 (B\<13\> n1586 n1253 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1128 (n1248 n1753 n1246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1129 (A\<13\> n1586 n1248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U520 (n578 n71 n569 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U521 (n579 n580 n578 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U525 (n1813 n133 n579 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U512 (n571 n1645 n570 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U511 (n569 n570 n566 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U649 (n734 n735 n728 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U650 (n1813 n1651 n735 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U645 (n731 n1585 n729 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U640 (n724 n723 n716 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U642 (n726 n1646 n723 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U625 (n706 n707 n705 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U531 (n1645 n1602 n455 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1547 (B\<3\> n1641 n721 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U230 (n1697 n1791 n245 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U228 (n245 n246 n244 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U229 (n1724 n1590 n246 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U340 (n1697 n1590 n364 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U920 (n1033 n1032 n1030 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U922 (n1697 n65 n1032 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1381 (n65 n1563 n1432 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U921 (n1724 n1815 n1033 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U339 (n152 n47 n365 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1444 (n1633 n1790 n1471 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U233 (n1633 n47 n247 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U338 (n364 n365 n363 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U342 (n1698 n1789 n367 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U343 (n1784 n134 n366 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U341 (n366 n367 n362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U758 (n849 n850 n829 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U738 (n831 n1786 n830 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U774 (n146 n1675 n866 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U667 (n1797 n1675 n757 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U666 (n756 n757 n754 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U668 (n637 n1799 n756 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U773 (n1702 n1667 n867 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U772 (n867 n866 n861 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U740 (n1787 n1717 n834 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U739 (n834 n833 n832 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U630 (n712 n1867 n710 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U631 (n713 n714 n712 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U628 (n711 n710 n708 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U957 (n1790 n1717 n1069 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U329 (n1669 n1757 n353 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U318 (n341 n342 n340 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U940 (n1731 n67 n1051 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1379 (n1086 n21 n1421 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1366 (n1421 n1803 n687 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U942 (n1053 n1581 n1052 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1293 (B\<11\> n1663 n1373 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1265 (n1355 n1356 n1354 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1271 (A\<11\> n1611 n1362 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U535 (n596 n1612 n594 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1270 (n1362 n1612 n1360 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1294 (n1374 n1375 n1353 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U972 (n1582 n1608 n1085 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U971 (n1084 n1085 n202 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U983 (n152 n1608 n1095 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U984 (n1697 n1839 n1094 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U982 (n1094 n1095 n1089 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U941 (n1052 n89 n1049 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1474 (n1731 n1704 n219 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1020 (n1849 n1704 n668 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U312 (n1697 n1829 n334 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U892 (n1806 n1718 n1001 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U954 (n146 n1667 n1067 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U599 (n675 n676 n673 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U601 (n146 n1718 n675 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U953 (n1067 n1785 n1055 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U956 (n1673 n1787 n1070 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U955 (n1069 n1070 n1068 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U623 (n1631 n1788 n694 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U618 (n695 n694 n692 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1443 (n1470 n1471 n1464 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1451 (n1619 n152 n1470 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U945 (n1057 n1776 n1056 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U600 (n1673 n1702 n676 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U937 (n1560 n1599 n1048 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U927 (n1038 n1039 n1037 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U932 (n1044 n1710 n1042 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U933 (A\<18\> n1664 n1044 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U205 (n1698 n1808 n218 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U880 (n980 n981 n969 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U881 (n1633 n1807 n981 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U885 (n151 n1808 n980 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U871 (n971 n972 n970 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U873 (n973 n113 n971 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U206 (n138 n48 n217 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U285 (n1697 n1802 n305 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U872 (n1697 n145 n972 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1104 (n1802 n138 n1220 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U204 (n217 n218 n214 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U513 (n572 n573 n571 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U232 (n1784 n150 n248 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U231 (n247 n248 n243 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1019 (n1631 n150 n1013 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U690 (n1631 n1819 n774 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U1391 (n1648 n1849 n294 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U968 (B\<4\> n21 n606 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
    U976 (n1668 n1601 n718 inh_gnd inh_gnds inh_vdd inh_vdds) \
        LVT_NOR2x1_PB4_AFBB
